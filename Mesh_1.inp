17479, -1.694673e-001, 3.200750e-001, 6.368335e-003
17480, -1.699382e-001, 3.209591e-001, 6.368335e-003
17481, -1.704091e-001, 3.218431e-001, 6.368335e-003
17482, -1.708800e-001, 3.227272e-001, 6.368335e-003
17483, -1.713509e-001, 3.236112e-001, 6.368335e-003
17484, -1.718218e-001, 3.244953e-001, 6.368335e-003
17485, -1.722927e-001, 3.253793e-001, 6.368335e-003
17486, -1.727636e-001, 3.262634e-001, 6.368335e-003
17487, -1.732345e-001, 3.271475e-001, 6.368335e-003
17488, -1.737054e-001, 3.280315e-001, 6.368335e-003
17489, -1.741763e-001, 3.289156e-001, 6.368335e-003
17490, -1.746472e-001, 3.297996e-001, 6.368335e-003
17491, -1.751182e-001, 3.306837e-001, 6.368335e-003
17492, -1.755891e-001, 3.315678e-001, 6.368335e-003
17493, -1.760600e-001, 3.324518e-001, 6.368335e-003
17494, -1.765309e-001, 3.333359e-001, 6.368335e-003
17495, -1.770018e-001, 3.342199e-001, 6.368335e-003
17496, -1.774727e-001, 3.351040e-001, 6.368335e-003
17497, -1.779436e-001, 3.359881e-001, 6.368335e-003
17498, -1.784145e-001, 3.368721e-001, 6.368335e-003
17499, -1.788854e-001, 3.377562e-001, 6.368336e-003
17500, -1.793563e-001, 3.386402e-001, 6.368336e-003
17501, -1.798272e-001, 3.395243e-001, 6.368336e-003
17502, -1.802981e-001, 3.404083e-001, 6.368336e-003
17503, -1.807690e-001, 3.412924e-001, 6.368336e-003
17504, -1.812399e-001, 3.421765e-001, 6.368336e-003
17505, -1.817109e-001, 3.430605e-001, 6.368336e-003
17506, -1.821818e-001, 3.439446e-001, 6.368336e-003
17507, -1.826527e-001, 3.448286e-001, 6.368336e-003
17508, -1.831236e-001, 3.457127e-001, 6.368336e-003
17509, -1.835945e-001, 3.465968e-001, 6.368336e-003
17510, -1.840654e-001, 3.474808e-001, 6.368336e-003
17511, -1.845363e-001, 3.483649e-001, 6.368336e-003
17512, -1.850072e-001, 3.492489e-001, 6.368336e-003
17513, -1.854781e-001, 3.501330e-001, 6.368336e-003
17514, -1.859490e-001, 3.510170e-001, 6.368336e-003
17515, -1.864199e-001, 3.519011e-001, 6.368336e-003
17516, -1.868908e-001, 3.527852e-001, 6.368336e-003
17517, -1.873617e-001, 3.536692e-001, 6.368336e-003
17518, -1.878326e-001, 3.545533e-001, 6.368336e-003
17519, -1.883036e-001, 3.554373e-001, 6.368336e-003
17520, -1.887745e-001, 3.563214e-001, 6.368336e-003
17521, -1.892454e-001, 3.572054e-001, 6.368336e-003
17522, -1.897163e-001, 3.580895e-001, 6.368336e-003
17523, -1.901872e-001, 3.589736e-001, 6.368336e-003
17524, -1.906581e-001, 3.598576e-001, 6.368336e-003
17525, -1.911290e-001, 3.607417e-001, 6.368336e-003
17526, -1.915999e-001, 3.616257e-001, 6.368336e-003
17527, -1.920708e-001, 3.625098e-001, 6.368336e-003
17528, -1.925417e-001, 3.633939e-001, 6.368336e-003
17529, -1.930126e-001, 3.642779e-001, 6.368336e-003
17530, -1.934835e-001, 3.651620e-001, 6.368336e-003
17531, -1.939544e-001, 3.660460e-001, 6.368336e-003
17532, -1.944253e-001, 3.669301e-001, 6.368336e-003
17533, -1.948962e-001, 3.678141e-001, 6.368336e-003
17534, -1.953672e-001, 3.686982e-001, 6.368336e-003
17535, -1.958381e-001, 3.695823e-001, 6.368336e-003
17536, -1.963090e-001, 3.704663e-001, 6.368336e-003
17537, -1.967799e-001, 3.713504e-001, 6.368336e-003
17538, -1.972508e-001, 3.722344e-001, 6.368336e-003
17539, -1.977217e-001, 3.731185e-001, 6.368336e-003
17540, -1.981926e-001, 3.740025e-001, 6.368336e-003
17541, -1.986635e-001, 3.748866e-001, 6.368336e-003
17542, -1.991344e-001, 3.757707e-001, 6.368336e-003
17543, -1.996053e-001, 3.766547e-001, 6.368336e-003
17544, -2.000762e-001, 3.775388e-001, 6.368336e-003
17545, -2.005471e-001, 3.784228e-001, 6.368336e-003
17546, -2.010180e-001, 3.793069e-001, 6.368336e-003
17547, -2.014889e-001, 3.801909e-001, 6.368336e-003
17548, -2.019599e-001, 3.810750e-001, 6.368337e-003
17549, -2.024309e-001, 3.819593e-001, 6.368332e-003
17550, -2.029021e-001, 3.828440e-001, 6.368308e-003
17551, -2.033735e-001, 3.837293e-001, 6.368263e-003
17552, -2.038450e-001, 3.846148e-001, 6.368206e-003
17553, -2.043165e-001, 3.855001e-001, 6.368154e-003
17554, -2.047877e-001, 3.863849e-001, 6.368118e-003
17555, -2.052587e-001, 3.872692e-001, 6.368099e-003
17556, -2.057296e-001, 3.881533e-001, 6.368090e-003
17557, -2.062005e-001, 3.890373e-001, 6.368085e-003
17558, -2.066713e-001, 3.899212e-001, 6.368081e-003
17559, -2.071421e-001, 3.908051e-001, 6.368080e-003
17560, -2.076129e-001, 3.916889e-001, 6.368079e-003
17561, -2.080836e-001, 3.925727e-001, 6.368077e-003
17562, -2.085544e-001, 3.934566e-001, 6.368076e-003
17563, -2.090252e-001, 3.943403e-001, 6.368078e-003
17564, -2.094960e-001, 3.952241e-001, 6.368080e-003
17565, -2.099667e-001, 3.961080e-001, 6.368079e-003
17566, -2.104375e-001, 3.969918e-001, 6.368078e-003
17567, -2.109084e-001, 3.978757e-001, 6.368077e-003
17568, -2.113792e-001, 3.987596e-001, 6.368079e-003
17569, -2.118500e-001, 3.996435e-001, 6.368083e-003
17570, -2.123208e-001, 4.005273e-001, 6.368089e-003
17571, -2.127916e-001, 4.014112e-001, 6.368092e-003
17572, -2.132624e-001, 4.022950e-001, 6.368086e-003
17573, -2.137332e-001, 4.031790e-001, 6.368055e-003
17574, -2.142040e-001, 4.040631e-001, 6.367988e-003
17575, -1.318456e-001, 2.492700e-001, 6.405410e-003
17576, -1.348465e-001, 2.547896e-001, 6.428801e-003
17577, -2.174631e-001, 3.978175e-001, 6.368257e-003
17578, -2.137069e-001, 3.907664e-001, 6.368366e-003
17579, -2.141764e-001, 3.916476e-001, 6.368353e-003
17580, -2.146458e-001, 3.925289e-001, 6.368339e-003
17581, -1.388410e-001, 2.626414e-001, 6.354809e-003
17582, -2.188714e-001, 4.004598e-001, 6.367920e-003
17583, -1.322489e-001, 2.503243e-001, 6.342014e-003
17584, -2.127678e-001, 3.890033e-001, 6.368356e-003
17585, -2.132373e-001, 3.898847e-001, 6.368354e-003
17586, -2.122983e-001, 3.881219e-001, 6.368354e-003
17587, -2.118288e-001, 3.872405e-001, 6.368359e-003
17588, -2.113592e-001, 3.863588e-001, 6.368350e-003
17589, -2.108897e-001, 3.854773e-001, 6.368347e-003
17590, -2.104202e-001, 3.845959e-001, 6.368351e-003
17591, -2.099505e-001, 3.837143e-001, 6.368350e-003
17592, -2.094806e-001, 3.828319e-001, 6.368323e-003
17593, -2.090104e-001, 3.819490e-001, 6.368272e-003
17594, -2.085402e-001, 3.810659e-001, 6.368215e-003
17595, -2.080700e-001, 3.801830e-001, 6.368166e-003
17596, -2.076000e-001, 3.793005e-001, 6.368132e-003
17597, -2.071302e-001, 3.784183e-001, 6.368113e-003
17598, -2.066604e-001, 3.775363e-001, 6.368103e-003
17599, -2.061907e-001, 3.766545e-001, 6.368099e-003
17600, -2.057210e-001, 3.757728e-001, 6.368098e-003
17601, -2.052514e-001, 3.748911e-001, 6.368097e-003
17602, -2.047817e-001, 3.740094e-001, 6.368097e-003
17603, -2.043121e-001, 3.731277e-001, 6.368098e-003
17604, -2.038424e-001, 3.722460e-001, 6.368098e-003
17605, -2.033728e-001, 3.713643e-001, 6.368098e-003
17606, -2.029031e-001, 3.704826e-001, 6.368099e-003
17607, -2.024335e-001, 3.696009e-001, 6.368099e-003
17608, -2.019638e-001, 3.687192e-001, 6.368099e-003
17609, -2.014942e-001, 3.678375e-001, 6.368100e-003
17610, -2.010245e-001, 3.669558e-001, 6.368100e-003
17611, -2.005549e-001, 3.660741e-001, 6.368101e-003
17612, -2.000852e-001, 3.651924e-001, 6.368101e-003
17613, -1.996156e-001, 3.643107e-001, 6.368102e-003
17614, -1.991459e-001, 3.634290e-001, 6.368102e-003
17615, -1.986763e-001, 3.625473e-001, 6.368103e-003
17616, -1.982066e-001, 3.616656e-001, 6.368103e-003
17617, -1.977370e-001, 3.607839e-001, 6.368104e-003
17618, -1.972673e-001, 3.599022e-001, 6.368104e-003
17619, -1.967977e-001, 3.590205e-001, 6.368105e-003
17620, -1.963280e-001, 3.581388e-001, 6.368105e-003
17621, -1.958584e-001, 3.572571e-001, 6.368106e-003
17622, -1.953887e-001, 3.563754e-001, 6.368106e-003
17623, -1.949191e-001, 3.554937e-001, 6.368107e-003
17624, -1.944494e-001, 3.546121e-001, 6.368108e-003
17625, -1.939798e-001, 3.537304e-001, 6.368108e-003
17626, -1.935101e-001, 3.528487e-001, 6.368109e-003
17627, -1.930405e-001, 3.519670e-001, 6.368110e-003
17628, -1.925708e-001, 3.510853e-001, 6.368110e-003
17629, -1.921012e-001, 3.502036e-001, 6.368111e-003
17630, -1.916315e-001, 3.493219e-001, 6.368112e-003
17631, -1.911619e-001, 3.484402e-001, 6.368113e-003
17632, -1.906922e-001, 3.475585e-001, 6.368113e-003
17633, -1.902226e-001, 3.466768e-001, 6.368114e-003
17634, -1.897529e-001, 3.457951e-001, 6.368115e-003
17635, -1.892833e-001, 3.449134e-001, 6.368116e-003
17636, -1.888136e-001, 3.440318e-001, 6.368117e-003
17637, -1.883440e-001, 3.431501e-001, 6.368117e-003
17638, -1.878743e-001, 3.422684e-001, 6.368118e-003
17639, -1.874047e-001, 3.413867e-001, 6.368119e-003
17640, -1.869351e-001, 3.405050e-001, 6.368120e-003
17641, -1.864654e-001, 3.396233e-001, 6.368121e-003
17642, -1.859958e-001, 3.387416e-001, 6.368122e-003
17643, -1.855261e-001, 3.378599e-001, 6.368123e-003
17644, -1.850565e-001, 3.369782e-001, 6.368124e-003
17645, -1.845868e-001, 3.360966e-001, 6.368125e-003
17646, -1.841172e-001, 3.352149e-001, 6.368126e-003
17647, -1.836475e-001, 3.343332e-001, 6.368127e-003
17648, -1.831779e-001, 3.334515e-001, 6.368128e-003
17649, -1.827082e-001, 3.325698e-001, 6.368129e-003
17650, -1.822386e-001, 3.316881e-001, 6.368130e-003
17651, -1.817689e-001, 3.308064e-001, 6.368132e-003
17652, -1.812993e-001, 3.299248e-001, 6.368133e-003
17653, -1.808297e-001, 3.290431e-001, 6.368134e-003
17654, -1.803600e-001, 3.281614e-001, 6.368135e-003
17655, -1.798904e-001, 3.272797e-001, 6.368136e-003
17656, -1.794207e-001, 3.263980e-001, 6.368138e-003
17657, -1.789511e-001, 3.255163e-001, 6.368139e-003
17658, -1.784814e-001, 3.246347e-001, 6.368140e-003
17659, -1.780118e-001, 3.237530e-001, 6.368142e-003
17660, -1.775421e-001, 3.228713e-001, 6.368143e-003
17661, -1.770725e-001, 3.219896e-001, 6.368144e-003
17662, -1.766028e-001, 3.211079e-001, 6.368146e-003
17663, -1.761332e-001, 3.202262e-001, 6.368147e-003
17664, -1.756636e-001, 3.193446e-001, 6.368149e-003
17665, -1.751939e-001, 3.184629e-001, 6.368150e-003
17666, -1.747243e-001, 3.175812e-001, 6.368152e-003
17667, -1.742546e-001, 3.166995e-001, 6.368154e-003
17668, -1.737850e-001, 3.158178e-001, 6.368155e-003
17669, -1.733153e-001, 3.149362e-001, 6.368157e-003
17670, -1.728457e-001, 3.140545e-001, 6.368158e-003
17671, -1.723760e-001, 3.131728e-001, 6.368160e-003
17672, -1.719064e-001, 3.122911e-001, 6.368162e-003
17673, -1.714368e-001, 3.114094e-001, 6.368164e-003
17674, -1.709671e-001, 3.105278e-001, 6.368165e-003
17675, -1.704975e-001, 3.096461e-001, 6.368167e-003
17676, -1.700278e-001, 3.087644e-001, 6.368169e-003
17677, -1.695582e-001, 3.078827e-001, 6.368171e-003
17678, -1.690885e-001, 3.070011e-001, 6.368173e-003
17679, -1.686189e-001, 3.061194e-001, 6.368175e-003
17680, -1.681493e-001, 3.052377e-001, 6.368177e-003
17681, -1.676796e-001, 3.043560e-001, 6.368179e-003
17682, -1.672100e-001, 3.034743e-001, 6.368181e-003
17683, -1.667403e-001, 3.025927e-001, 6.368183e-003
17684, -1.662707e-001, 3.017110e-001, 6.368185e-003
17685, -1.658010e-001, 3.008293e-001, 6.368187e-003
17686, -1.653314e-001, 2.999476e-001, 6.368189e-003
17687, -1.648618e-001, 2.990660e-001, 6.368192e-003
17688, -1.643921e-001, 2.981843e-001, 6.368194e-003
17689, -1.639225e-001, 2.973026e-001, 6.368196e-003
17690, -1.634528e-001, 2.964210e-001, 6.368198e-003
17691, -1.629832e-001, 2.955393e-001, 6.368201e-003
17692, -1.625135e-001, 2.946576e-001, 6.368203e-003
17693, -1.620439e-001, 2.937759e-001, 6.368206e-003
17694, -1.615743e-001, 2.928943e-001, 6.368208e-003
17695, -1.611046e-001, 2.920126e-001, 6.368211e-003
17696, -1.606350e-001, 2.911309e-001, 6.368213e-003
17697, -1.601653e-001, 2.902492e-001, 6.368216e-003
17698, -1.596957e-001, 2.893676e-001, 6.368218e-003
17699, -1.592260e-001, 2.884859e-001, 6.368221e-003
17700, -1.587564e-001, 2.876042e-001, 6.368224e-003
17701, -1.582868e-001, 2.867226e-001, 6.368226e-003
17702, -1.578171e-001, 2.858409e-001, 6.368229e-003
17703, -1.573475e-001, 2.849592e-001, 6.368232e-003
17704, -1.568778e-001, 2.840776e-001, 6.368235e-003
17705, -1.564082e-001, 2.831959e-001, 6.368238e-003
17706, -1.559386e-001, 2.823142e-001, 6.368241e-003
17707, -1.554689e-001, 2.814326e-001, 6.368244e-003
17708, -1.549993e-001, 2.805509e-001, 6.368247e-003
17709, -1.545296e-001, 2.796692e-001, 6.368250e-003
17710, -1.540600e-001, 2.787876e-001, 6.368253e-003
17711, -1.535904e-001, 2.779059e-001, 6.368256e-003
17712, -1.531207e-001, 2.770242e-001, 6.368259e-003
17713, -1.526511e-001, 2.761426e-001, 6.368262e-003
17714, -1.521814e-001, 2.752609e-001, 6.368266e-003
17715, -1.517118e-001, 2.743792e-001, 6.368269e-003
17716, -1.512421e-001, 2.734975e-001, 6.368275e-003
17717, -1.507724e-001, 2.726158e-001, 6.368281e-003
17718, -1.503027e-001, 2.717339e-001, 6.368285e-003
17719, -1.498330e-001, 2.708521e-001, 6.368292e-003
17720, -1.493634e-001, 2.699707e-001, 6.368304e-003
17721, -1.488940e-001, 2.690895e-001, 6.368321e-003
17722, -1.484246e-001, 2.682083e-001, 6.368339e-003
17723, -1.479549e-001, 2.673267e-001, 6.368345e-003
17724, -1.474852e-001, 2.664448e-001, 6.368346e-003
17725, -1.470156e-001, 2.655633e-001, 6.368354e-003
17726, -1.465458e-001, 2.646812e-001, 6.368363e-003
17727, -1.460751e-001, 2.637995e-001, 6.368789e-003
17728, -1.456020e-001, 2.629233e-001, 6.371352e-003
17729, -1.451239e-001, 2.620609e-001, 6.378857e-003
17730, -1.446327e-001, 2.612153e-001, 6.394971e-003
17731, -1.440983e-001, 2.603603e-001, 6.425554e-003
17732, -1.406447e-001, 2.639856e-001, 6.715501e-003
17733, -1.401574e-001, 2.631096e-001, 6.710089e-003
17734, -1.369102e-001, 2.579548e-001, 6.562390e-003
17735, -1.366940e-001, 2.570521e-001, 6.644429e-003
17736, -2.171828e-001, 4.013549e-001, 6.928820e-003
17737, -2.163027e-001, 4.018204e-001, 7.000000e-003
17738, -1.351882e-001, 2.533827e-001, 6.762879e-003
17739, -1.358334e-001, 2.544405e-001, 6.781738e-003
17740, -1.367400e-001, 2.557967e-001, 6.821251e-003
17741, -1.380525e-001, 2.565998e-001, 6.955170e-003
17742, -1.390155e-001, 2.574913e-001, 6.990729e-003
17743, -1.400342e-001, 2.584578e-001, 6.999489e-003
17744, -1.413168e-001, 2.593947e-001, 6.956846e-003
17745, -1.425413e-001, 2.600829e-001, 6.830002e-003
17746, -1.331309e-001, 2.502407e-001, 6.663201e-003
17747, -1.420555e-001, 2.666239e-001, 6.716899e-003
17748, -1.415871e-001, 2.657450e-001, 6.716837e-003
17749, -2.161667e-001, 3.973744e-001, 6.717013e-003
17750, -2.166362e-001, 3.982555e-001, 6.716957e-003
17751, -2.152274e-001, 3.956114e-001, 6.717054e-003
17752, -2.156970e-001, 3.964927e-001, 6.717023e-003
17753, -1.387171e-001, 2.605215e-001, 6.693675e-003
17754, -1.382202e-001, 2.596161e-001, 6.689694e-003
17755, -2.180449e-001, 4.008982e-001, 6.716709e-003
17756, -1.396436e-001, 2.622478e-001, 6.695545e-003
17757, -1.391365e-001, 2.614062e-001, 6.679507e-003
17758, -2.124096e-001, 3.903214e-001, 6.717067e-003
17759, -2.128792e-001, 3.912029e-001, 6.717059e-003
17760, -2.133487e-001, 3.920843e-001, 6.717050e-003
17761, -2.138183e-001, 3.929658e-001, 6.717042e-003
17762, -2.110008e-001, 3.876766e-001, 6.717065e-003
17763, -2.114702e-001, 3.885577e-001, 6.717049e-003
17764, -2.154225e-001, 4.022857e-001, 6.928844e-003
17765, -1.411193e-001, 2.648687e-001, 6.716582e-003
17766, -1.425266e-001, 2.675083e-001, 6.716925e-003
17767, -1.429973e-001, 2.683917e-001, 6.716941e-003
17768, -1.434687e-001, 2.692767e-001, 6.716936e-003
17769, -1.439388e-001, 2.701593e-001, 6.716943e-003
17770, -1.444094e-001, 2.710428e-001, 6.716949e-003
17771, -1.448799e-001, 2.719260e-001, 6.716964e-003
17772, -1.453505e-001, 2.728093e-001, 6.716983e-003
17773, -1.458214e-001, 2.736931e-001, 6.716997e-003
17774, -1.462923e-001, 2.745773e-001, 6.717006e-003
17775, -1.467633e-001, 2.754614e-001, 6.717011e-003
17776, -1.472342e-001, 2.763454e-001, 6.717014e-003
17777, -1.477051e-001, 2.772294e-001, 6.717015e-003
17778, -1.481759e-001, 2.781133e-001, 6.717016e-003
17779, -1.486467e-001, 2.789972e-001, 6.717017e-003
17780, -1.491175e-001, 2.798811e-001, 6.717018e-003
17781, -1.495884e-001, 2.807649e-001, 6.717018e-003
17782, -1.500592e-001, 2.816488e-001, 6.717018e-003
17783, -1.505300e-001, 2.825327e-001, 6.717019e-003
17784, -1.510008e-001, 2.834165e-001, 6.717019e-003
17785, -1.514716e-001, 2.843004e-001, 6.717019e-003
17786, -1.519424e-001, 2.851843e-001, 6.717020e-003
17787, -1.524132e-001, 2.860681e-001, 6.717020e-003
17788, -1.528840e-001, 2.869520e-001, 6.717020e-003
17789, -1.533548e-001, 2.878359e-001, 6.717021e-003
17790, -1.538256e-001, 2.887197e-001, 6.717021e-003
17791, -1.542964e-001, 2.896036e-001, 6.717021e-003
17792, -1.547672e-001, 2.904875e-001, 6.717022e-003
17793, -1.552380e-001, 2.913713e-001, 6.717022e-003
17794, -1.557088e-001, 2.922552e-001, 6.717022e-003
17795, -1.561796e-001, 2.931390e-001, 6.717023e-003
17796, -1.566504e-001, 2.940229e-001, 6.717023e-003
17797, -1.571212e-001, 2.949068e-001, 6.717023e-003
17798, -1.575920e-001, 2.957906e-001, 6.717023e-003
17799, -1.580628e-001, 2.966745e-001, 6.717024e-003
17800, -1.585337e-001, 2.975584e-001, 6.717024e-003
17801, -1.590045e-001, 2.984422e-001, 6.717024e-003
17802, -1.594753e-001, 2.993261e-001, 6.717025e-003
17803, -1.599461e-001, 3.002100e-001, 6.717025e-003
17804, -1.604169e-001, 3.010938e-001, 6.717025e-003
17805, -1.608877e-001, 3.019777e-001, 6.717025e-003
17806, -1.613585e-001, 3.028616e-001, 6.717026e-003
17807, -1.618293e-001, 3.037454e-001, 6.717026e-003
17808, -1.623001e-001, 3.046293e-001, 6.717026e-003
17809, -1.627709e-001, 3.055131e-001, 6.717027e-003
17810, -1.632417e-001, 3.063970e-001, 6.717027e-003
17811, -1.637125e-001, 3.072809e-001, 6.717027e-003
17812, -1.641833e-001, 3.081647e-001, 6.717027e-003
17813, -1.646541e-001, 3.090486e-001, 6.717028e-003
17814, -1.651249e-001, 3.099325e-001, 6.717028e-003
17815, -1.655957e-001, 3.108163e-001, 6.717028e-003
17816, -1.660665e-001, 3.117002e-001, 6.717028e-003
17817, -1.665373e-001, 3.125841e-001, 6.717029e-003
17818, -1.670081e-001, 3.134679e-001, 6.717029e-003
17819, -1.674789e-001, 3.143518e-001, 6.717029e-003
17820, -1.679497e-001, 3.152356e-001, 6.717029e-003
17821, -1.684205e-001, 3.161195e-001, 6.717030e-003
17822, -1.688913e-001, 3.170034e-001, 6.717030e-003
17823, -1.693622e-001, 3.178872e-001, 6.717030e-003
17824, -1.698330e-001, 3.187711e-001, 6.717030e-003
17825, -1.703038e-001, 3.196550e-001, 6.717030e-003
17826, -1.707746e-001, 3.205388e-001, 6.717031e-003
17827, -1.712454e-001, 3.214227e-001, 6.717031e-003
17828, -1.717162e-001, 3.223066e-001, 6.717031e-003
17829, -1.721870e-001, 3.231904e-001, 6.717031e-003
17830, -1.726578e-001, 3.240743e-001, 6.717031e-003
17831, -1.731286e-001, 3.249581e-001, 6.717032e-003
17832, -1.735994e-001, 3.258420e-001, 6.717032e-003
17833, -1.740702e-001, 3.267259e-001, 6.717032e-003
17834, -1.745410e-001, 3.276097e-001, 6.717032e-003
17835, -1.750118e-001, 3.284936e-001, 6.717032e-003
17836, -1.754826e-001, 3.293775e-001, 6.717033e-003
17837, -1.759534e-001, 3.302613e-001, 6.717033e-003
17838, -1.764242e-001, 3.311452e-001, 6.717033e-003
17839, -1.768950e-001, 3.320290e-001, 6.717033e-003
17840, -1.773658e-001, 3.329129e-001, 6.717033e-003
17841, -1.778366e-001, 3.337968e-001, 6.717033e-003
17842, -1.783074e-001, 3.346806e-001, 6.717034e-003
17843, -1.787782e-001, 3.355645e-001, 6.717034e-003
17844, -1.792490e-001, 3.364484e-001, 6.717034e-003
17845, -1.797198e-001, 3.373322e-001, 6.717034e-003
17846, -1.801906e-001, 3.382161e-001, 6.717034e-003
17847, -1.806614e-001, 3.390999e-001, 6.717034e-003
17848, -1.811322e-001, 3.399838e-001, 6.717034e-003
17849, -1.816030e-001, 3.408677e-001, 6.717035e-003
17850, -1.820738e-001, 3.417515e-001, 6.717035e-003
17851, -1.825447e-001, 3.426354e-001, 6.717035e-003
17852, -1.830155e-001, 3.435193e-001, 6.717035e-003
17853, -1.834863e-001, 3.444031e-001, 6.717035e-003
17854, -1.839571e-001, 3.452870e-001, 6.717035e-003
17855, -1.844279e-001, 3.461708e-001, 6.717035e-003
17856, -1.848987e-001, 3.470547e-001, 6.717035e-003
17857, -1.853695e-001, 3.479386e-001, 6.717036e-003
17858, -1.858403e-001, 3.488224e-001, 6.717036e-003
17859, -1.863111e-001, 3.497063e-001, 6.717036e-003
17860, -1.867819e-001, 3.505902e-001, 6.717036e-003
17861, -1.872527e-001, 3.514740e-001, 6.717036e-003
17862, -1.877235e-001, 3.523579e-001, 6.717036e-003
17863, -1.881943e-001, 3.532417e-001, 6.717036e-003
17864, -1.886651e-001, 3.541256e-001, 6.717036e-003
17865, -1.891359e-001, 3.550095e-001, 6.717036e-003
17866, -1.896067e-001, 3.558933e-001, 6.717036e-003
17867, -1.900775e-001, 3.567772e-001, 6.717037e-003
17868, -1.905483e-001, 3.576611e-001, 6.717037e-003
17869, -1.910191e-001, 3.585449e-001, 6.717037e-003
17870, -1.914899e-001, 3.594288e-001, 6.717037e-003
17871, -1.919607e-001, 3.603126e-001, 6.717037e-003
17872, -1.924315e-001, 3.611965e-001, 6.717037e-003
17873, -1.929023e-001, 3.620804e-001, 6.717037e-003
17874, -1.933731e-001, 3.629642e-001, 6.717037e-003
17875, -1.938439e-001, 3.638481e-001, 6.717037e-003
17876, -1.943147e-001, 3.647319e-001, 6.717037e-003
17877, -1.947855e-001, 3.656158e-001, 6.717037e-003
17878, -1.952563e-001, 3.664997e-001, 6.717037e-003
17879, -1.957271e-001, 3.673835e-001, 6.717037e-003
17880, -1.961979e-001, 3.682674e-001, 6.717038e-003
17881, -1.966687e-001, 3.691513e-001, 6.717038e-003
17882, -1.971395e-001, 3.700351e-001, 6.717038e-003
17883, -1.976103e-001, 3.709190e-001, 6.717038e-003
17884, -1.980811e-001, 3.718028e-001, 6.717038e-003
17885, -1.985519e-001, 3.726867e-001, 6.717038e-003
17886, -1.990227e-001, 3.735706e-001, 6.717038e-003
17887, -1.994935e-001, 3.744544e-001, 6.717038e-003
17888, -1.999644e-001, 3.753383e-001, 6.717038e-003
17889, -2.004352e-001, 3.762221e-001, 6.717038e-003
17890, -2.009060e-001, 3.771060e-001, 6.717038e-003
17891, -2.013768e-001, 3.779899e-001, 6.717038e-003
17892, -2.018476e-001, 3.788737e-001, 6.717038e-003
17893, -2.023184e-001, 3.797576e-001, 6.717038e-003
17894, -2.027893e-001, 3.806417e-001, 6.717034e-003
17895, -2.032604e-001, 3.815263e-001, 6.717016e-003
17896, -2.037319e-001, 3.824118e-001, 6.716977e-003
17897, -2.042037e-001, 3.832979e-001, 6.716918e-003
17898, -2.046755e-001, 3.841841e-001, 6.716852e-003
17899, -2.051471e-001, 3.850699e-001, 6.716793e-003
17900, -2.056184e-001, 3.859550e-001, 6.716753e-003
17901, -2.060894e-001, 3.868394e-001, 6.716731e-003
17902, -2.065602e-001, 3.877233e-001, 6.716720e-003
17903, -2.070309e-001, 3.886070e-001, 6.716714e-003
17904, -2.075015e-001, 3.894906e-001, 6.716709e-003
17905, -2.079721e-001, 3.903740e-001, 6.716708e-003
17906, -2.084427e-001, 3.912575e-001, 6.716706e-003
17907, -2.089133e-001, 3.921410e-001, 6.716703e-003
17908, -2.093838e-001, 3.930243e-001, 6.716703e-003
17909, -2.098543e-001, 3.939077e-001, 6.716706e-003
17910, -2.103249e-001, 3.947911e-001, 6.716708e-003
17911, -2.107955e-001, 3.956745e-001, 6.716707e-003
17912, -2.112661e-001, 3.965581e-001, 6.716705e-003
17913, -2.117367e-001, 3.974416e-001, 6.716705e-003
17914, -2.122074e-001, 3.983251e-001, 6.716712e-003
17915, -2.126780e-001, 3.992085e-001, 6.716724e-003
17916, -2.131485e-001, 4.000918e-001, 6.716739e-003
17917, -2.136191e-001, 4.009750e-001, 6.716755e-003
17918, -2.140896e-001, 4.018583e-001, 6.716769e-003
17919, -2.145601e-001, 4.027417e-001, 6.716766e-003
17920, -2.119397e-001, 3.894390e-001, 6.717037e-003
17921, -2.142879e-001, 3.938474e-001, 6.717038e-003
17922, -1.375590e-001, 2.587093e-001, 6.639221e-003
17923, -2.105309e-001, 3.867943e-001, 6.717045e-003
17924, -2.100612e-001, 3.859125e-001, 6.717043e-003
17925, -2.095915e-001, 3.850307e-001, 6.717044e-003
17926, -2.091216e-001, 3.841484e-001, 6.717033e-003
17927, -2.086511e-001, 3.832648e-001, 6.716987e-003
17928, -2.081803e-001, 3.823805e-001, 6.716923e-003
17929, -2.077094e-001, 3.814960e-001, 6.716857e-003
17930, -2.072387e-001, 3.806119e-001, 6.716801e-003
17931, -2.067682e-001, 3.797284e-001, 6.716762e-003
17932, -2.062980e-001, 3.788454e-001, 6.716739e-003
17933, -2.058280e-001, 3.779629e-001, 6.716728e-003
17934, -2.053580e-001, 3.770806e-001, 6.716723e-003
17935, -2.048881e-001, 3.761984e-001, 6.716721e-003
17936, -2.044182e-001, 3.753162e-001, 6.716720e-003
17937, -2.039483e-001, 3.744341e-001, 6.716720e-003
17938, -2.034785e-001, 3.735520e-001, 6.716721e-003
17939, -2.030086e-001, 3.726699e-001, 6.716721e-003
17940, -2.025387e-001, 3.717878e-001, 6.716721e-003
17941, -2.020689e-001, 3.709057e-001, 6.716722e-003
17942, -2.015990e-001, 3.700236e-001, 6.716722e-003
17943, -2.011291e-001, 3.691415e-001, 6.716722e-003
17944, -2.006593e-001, 3.682594e-001, 6.716723e-003
17945, -2.001894e-001, 3.673773e-001, 6.716723e-003
17946, -1.997195e-001, 3.664952e-001, 6.716723e-003
17947, -1.992497e-001, 3.656131e-001, 6.716724e-003
17948, -1.987798e-001, 3.647310e-001, 6.716724e-003
17949, -1.983099e-001, 3.638489e-001, 6.716725e-003
17950, -1.978401e-001, 3.629668e-001, 6.716725e-003
17951, -1.973702e-001, 3.620847e-001, 6.716726e-003
17952, -1.969004e-001, 3.612026e-001, 6.716726e-003
17953, -1.964305e-001, 3.603205e-001, 6.716727e-003
17954, -1.959606e-001, 3.594384e-001, 6.716727e-003
17955, -1.954908e-001, 3.585563e-001, 6.716728e-003
17956, -1.950209e-001, 3.576742e-001, 6.716728e-003
17957, -1.945510e-001, 3.567921e-001, 6.716729e-003
17958, -1.940812e-001, 3.559100e-001, 6.716729e-003
17959, -1.936113e-001, 3.550279e-001, 6.716730e-003
17960, -1.931414e-001, 3.541458e-001, 6.716731e-003
17961, -1.926716e-001, 3.532637e-001, 6.716731e-003
17962, -1.922017e-001, 3.523816e-001, 6.716732e-003
17963, -1.917318e-001, 3.514995e-001, 6.716732e-003
17964, -1.912620e-001, 3.506174e-001, 6.716733e-003
17965, -1.907921e-001, 3.497353e-001, 6.716734e-003
17966, -1.903223e-001, 3.488533e-001, 6.716734e-003
17967, -1.898524e-001, 3.479712e-001, 6.716735e-003
17968, -1.893825e-001, 3.470891e-001, 6.716736e-003
17969, -1.889127e-001, 3.462070e-001, 6.716737e-003
17970, -1.884428e-001, 3.453249e-001, 6.716737e-003
17971, -1.879729e-001, 3.444428e-001, 6.716738e-003
17972, -1.875031e-001, 3.435607e-001, 6.716739e-003
17973, -1.870332e-001, 3.426786e-001, 6.716740e-003
17974, -1.865634e-001, 3.417965e-001, 6.716741e-003
17975, -1.860935e-001, 3.409144e-001, 6.716741e-003
17976, -1.856236e-001, 3.400323e-001, 6.716742e-003
17977, -1.851538e-001, 3.391502e-001, 6.716743e-003
17978, -1.846839e-001, 3.382682e-001, 6.716744e-003
17979, -1.842140e-001, 3.373861e-001, 6.716745e-003
17980, -1.837442e-001, 3.365040e-001, 6.716746e-003
17981, -1.832743e-001, 3.356219e-001, 6.716747e-003
17982, -1.828045e-001, 3.347398e-001, 6.716748e-003
17983, -1.823346e-001, 3.338577e-001, 6.716749e-003
17984, -1.818647e-001, 3.329756e-001, 6.716750e-003
17985, -1.813949e-001, 3.320935e-001, 6.716751e-003
17986, -1.809250e-001, 3.312115e-001, 6.716752e-003
17987, -1.804552e-001, 3.303294e-001, 6.716753e-003
17988, -1.799853e-001, 3.294473e-001, 6.716754e-003
17989, -1.795154e-001, 3.285652e-001, 6.716756e-003
17990, -1.790456e-001, 3.276831e-001, 6.716757e-003
17991, -1.785757e-001, 3.268010e-001, 6.716758e-003
17992, -1.781059e-001, 3.259189e-001, 6.716759e-003
17993, -1.776360e-001, 3.250369e-001, 6.716760e-003
17994, -1.771661e-001, 3.241548e-001, 6.716762e-003
17995, -1.766963e-001, 3.232727e-001, 6.716763e-003
17996, -1.762264e-001, 3.223906e-001, 6.716764e-003
17997, -1.757566e-001, 3.215085e-001, 6.716766e-003
17998, -1.752867e-001, 3.206264e-001, 6.716767e-003
17999, -1.748168e-001, 3.197444e-001, 6.716768e-003
18000, -1.743470e-001, 3.188623e-001, 6.716770e-003
18001, -1.738771e-001, 3.179802e-001, 6.716771e-003
18002, -1.734073e-001, 3.170981e-001, 6.716773e-003
18003, -1.729374e-001, 3.162160e-001, 6.716774e-003
18004, -1.724675e-001, 3.153340e-001, 6.716776e-003
18005, -1.719977e-001, 3.144519e-001, 6.716777e-003
18006, -1.715278e-001, 3.135698e-001, 6.716779e-003
18007, -1.710580e-001, 3.126877e-001, 6.716781e-003
18008, -1.705881e-001, 3.118056e-001, 6.716782e-003
18009, -1.701182e-001, 3.109236e-001, 6.716784e-003
18010, -1.696484e-001, 3.100415e-001, 6.716786e-003
18011, -1.691785e-001, 3.091594e-001, 6.716787e-003
18012, -1.687087e-001, 3.082773e-001, 6.716789e-003
18013, -1.682388e-001, 3.073953e-001, 6.716791e-003
18014, -1.677690e-001, 3.065132e-001, 6.716793e-003
18015, -1.672991e-001, 3.056311e-001, 6.716794e-003
18016, -1.668292e-001, 3.047490e-001, 6.716796e-003
18017, -1.663594e-001, 3.038670e-001, 6.716798e-003
18018, -1.658895e-001, 3.029849e-001, 6.716800e-003
18019, -1.654197e-001, 3.021028e-001, 6.716802e-003
18020, -1.649498e-001, 3.012207e-001, 6.716804e-003
18021, -1.644799e-001, 3.003387e-001, 6.716806e-003
18022, -1.640101e-001, 2.994566e-001, 6.716808e-003
18023, -1.635402e-001, 2.985745e-001, 6.716810e-003
18024, -1.630704e-001, 2.976924e-001, 6.716813e-003
18025, -1.626005e-001, 2.968104e-001, 6.716815e-003
18026, -1.621307e-001, 2.959283e-001, 6.716817e-003
18027, -1.616608e-001, 2.950462e-001, 6.716819e-003
18028, -1.611909e-001, 2.941642e-001, 6.716821e-003
18029, -1.607211e-001, 2.932821e-001, 6.716824e-003
18030, -1.602512e-001, 2.924000e-001, 6.716826e-003
18031, -1.597814e-001, 2.915180e-001, 6.716828e-003
18032, -1.593115e-001, 2.906359e-001, 6.716831e-003
18033, -1.588417e-001, 2.897538e-001, 6.716833e-003
18034, -1.583718e-001, 2.888717e-001, 6.716836e-003
18035, -1.579020e-001, 2.879897e-001, 6.716838e-003
18036, -1.574321e-001, 2.871076e-001, 6.716841e-003
18037, -1.569622e-001, 2.862255e-001, 6.716843e-003
18038, -1.564924e-001, 2.853435e-001, 6.716846e-003
18039, -1.560225e-001, 2.844614e-001, 6.716849e-003
18040, -1.555527e-001, 2.835793e-001, 6.716851e-003
18041, -1.550828e-001, 2.826973e-001, 6.716854e-003
18042, -1.546130e-001, 2.818152e-001, 6.716857e-003
18043, -1.541431e-001, 2.809332e-001, 6.716860e-003
18044, -1.536733e-001, 2.800511e-001, 6.716863e-003
18045, -1.532034e-001, 2.791690e-001, 6.716866e-003
18046, -1.527335e-001, 2.782870e-001, 6.716868e-003
18047, -1.522637e-001, 2.774049e-001, 6.716871e-003
18048, -1.517938e-001, 2.765228e-001, 6.716875e-003
18049, -1.513240e-001, 2.756408e-001, 6.716878e-003
18050, -1.508541e-001, 2.747587e-001, 6.716883e-003
18051, -1.503841e-001, 2.738765e-001, 6.716888e-003
18052, -1.499141e-001, 2.729941e-001, 6.716894e-003
18053, -1.494440e-001, 2.721116e-001, 6.716902e-003
18054, -1.489741e-001, 2.712295e-001, 6.716916e-003
18055, -1.485046e-001, 2.703483e-001, 6.716937e-003
18056, -1.480352e-001, 2.694673e-001, 6.716960e-003
18057, -1.475657e-001, 2.685859e-001, 6.716974e-003
18058, -1.470959e-001, 2.677040e-001, 6.716981e-003
18059, -1.466260e-001, 2.668218e-001, 6.716985e-003
18060, -1.461561e-001, 2.659396e-001, 6.716991e-003
18061, -1.456858e-001, 2.650576e-001, 6.717095e-003
18062, -1.452149e-001, 2.641787e-001, 6.717812e-003
18063, -1.447438e-001, 2.633106e-001, 6.720051e-003
18064, -1.442722e-001, 2.624617e-001, 6.725036e-003
18065, -1.437948e-001, 2.616394e-001, 6.734971e-003
18066, -1.432911e-001, 2.608478e-001, 6.755065e-003
18067, -2.171057e-001, 3.991364e-001, 6.716884e-003
18068, -2.175753e-001, 4.000172e-001, 6.716793e-003
18069, -2.147575e-001, 3.947290e-001, 6.717027e-003
18070, -2.149523e-001, 4.014032e-001, 6.928821e-003
18071, -1.375899e-001, 2.572956e-001, 6.831558e-003
18072, -1.383154e-001, 2.581599e-001, 6.879663e-003
18073, -1.391628e-001, 2.592253e-001, 6.921500e-003
18074, -1.406776e-001, 2.603778e-001, 6.995527e-003
18075, -1.438871e-001, 2.679880e-001, 6.928884e-003
18076, -1.434181e-001, 2.671076e-001, 6.928878e-003
18077, -2.143642e-001, 3.960657e-001, 6.928982e-003
18078, -2.148340e-001, 3.969474e-001, 6.928966e-003
18079, -2.101358e-001, 3.881275e-001, 6.928986e-003
18080, -2.106054e-001, 3.890091e-001, 6.928979e-003
18081, -2.115452e-001, 3.907736e-001, 6.928990e-003
18082, -2.120149e-001, 3.916554e-001, 6.928985e-003
18083, -2.158327e-001, 4.009386e-001, 7.000000e-003
18084, -1.404618e-001, 2.618268e-001, 6.909515e-003
18085, -1.399185e-001, 2.610723e-001, 6.888085e-003
18086, -1.410465e-001, 2.626889e-001, 6.926579e-003
18087, -2.124847e-001, 3.925371e-001, 6.928981e-003
18088, -2.129544e-001, 3.934190e-001, 6.928977e-003
18089, -2.082556e-001, 3.845975e-001, 6.928964e-003
18090, -2.087257e-001, 3.854801e-001, 6.928970e-003
18091, -1.424790e-001, 2.653433e-001, 6.928963e-003
18092, -1.420139e-001, 2.644672e-001, 6.929155e-003
18093, -1.448281e-001, 2.697545e-001, 6.928890e-003
18094, -1.443599e-001, 2.688756e-001, 6.928877e-003
18095, -1.452990e-001, 2.706384e-001, 6.928894e-003
18096, -1.457692e-001, 2.715210e-001, 6.928905e-003
18097, -1.462394e-001, 2.724035e-001, 6.928919e-003
18098, -1.467102e-001, 2.732872e-001, 6.928929e-003
18099, -1.471811e-001, 2.741712e-001, 6.928935e-003
18100, -1.476520e-001, 2.750551e-001, 6.928939e-003
18101, -1.481227e-001, 2.759389e-001, 6.928941e-003
18102, -1.485934e-001, 2.768225e-001, 6.928943e-003
18103, -1.490641e-001, 2.777061e-001, 6.928944e-003
18104, -1.495347e-001, 2.785897e-001, 6.928945e-003
18105, -1.500054e-001, 2.794732e-001, 6.928945e-003
18106, -1.504760e-001, 2.803567e-001, 6.928946e-003
18107, -1.509466e-001, 2.812402e-001, 6.928946e-003
18108, -1.514172e-001, 2.821237e-001, 6.928947e-003
18109, -1.518879e-001, 2.830072e-001, 6.928948e-003
18110, -1.523585e-001, 2.838908e-001, 6.928948e-003
18111, -1.528291e-001, 2.847743e-001, 6.928949e-003
18112, -1.532997e-001, 2.856578e-001, 6.928949e-003
18113, -1.537703e-001, 2.865413e-001, 6.928950e-003
18114, -1.542410e-001, 2.874248e-001, 6.928950e-003
18115, -1.547116e-001, 2.883083e-001, 6.928951e-003
18116, -1.551822e-001, 2.891918e-001, 6.928951e-003
18117, -1.556528e-001, 2.900754e-001, 6.928952e-003
18118, -1.561234e-001, 2.909589e-001, 6.928952e-003
18119, -1.565941e-001, 2.918424e-001, 6.928953e-003
18120, -1.570647e-001, 2.927259e-001, 6.928953e-003
18121, -1.575353e-001, 2.936094e-001, 6.928953e-003
18122, -1.580059e-001, 2.944929e-001, 6.928954e-003
18123, -1.584765e-001, 2.953764e-001, 6.928954e-003
18124, -1.589472e-001, 2.962599e-001, 6.928955e-003
18125, -1.594178e-001, 2.971435e-001, 6.928955e-003
18126, -1.598884e-001, 2.980270e-001, 6.928956e-003
18127, -1.603590e-001, 2.989105e-001, 6.928956e-003
18128, -1.608297e-001, 2.997940e-001, 6.928956e-003
18129, -1.613003e-001, 3.006775e-001, 6.928957e-003
18130, -1.617709e-001, 3.015610e-001, 6.928957e-003
18131, -1.622415e-001, 3.024445e-001, 6.928958e-003
18132, -1.627121e-001, 3.033281e-001, 6.928958e-003
18133, -1.631828e-001, 3.042116e-001, 6.928959e-003
18134, -1.636534e-001, 3.050951e-001, 6.928959e-003
18135, -1.641240e-001, 3.059786e-001, 6.928959e-003
18136, -1.645946e-001, 3.068621e-001, 6.928960e-003
18137, -1.650652e-001, 3.077456e-001, 6.928960e-003
18138, -1.655359e-001, 3.086291e-001, 6.928960e-003
18139, -1.660065e-001, 3.095127e-001, 6.928961e-003
18140, -1.664771e-001, 3.103962e-001, 6.928961e-003
18141, -1.669477e-001, 3.112797e-001, 6.928961e-003
18142, -1.674183e-001, 3.121632e-001, 6.928962e-003
18143, -1.678890e-001, 3.130467e-001, 6.928962e-003
18144, -1.683596e-001, 3.139302e-001, 6.928962e-003
18145, -1.688302e-001, 3.148137e-001, 6.928963e-003
18146, -1.693008e-001, 3.156973e-001, 6.928963e-003
18147, -1.697714e-001, 3.165808e-001, 6.928963e-003
18148, -1.702421e-001, 3.174643e-001, 6.928964e-003
18149, -1.707127e-001, 3.183478e-001, 6.928964e-003
18150, -1.711833e-001, 3.192313e-001, 6.928964e-003
18151, -1.716539e-001, 3.201148e-001, 6.928965e-003
18152, -1.721245e-001, 3.209983e-001, 6.928965e-003
18153, -1.725952e-001, 3.218819e-001, 6.928965e-003
18154, -1.730658e-001, 3.227654e-001, 6.928965e-003
18155, -1.735364e-001, 3.236489e-001, 6.928966e-003
18156, -1.740070e-001, 3.245324e-001, 6.928966e-003
18157, -1.744776e-001, 3.254159e-001, 6.928966e-003
18158, -1.749482e-001, 3.262994e-001, 6.928967e-003
18159, -1.754189e-001, 3.271829e-001, 6.928967e-003
18160, -1.758895e-001, 3.280665e-001, 6.928967e-003
18161, -1.763601e-001, 3.289500e-001, 6.928967e-003
18162, -1.768307e-001, 3.298335e-001, 6.928968e-003
18163, -1.773013e-001, 3.307170e-001, 6.928968e-003
18164, -1.777720e-001, 3.316005e-001, 6.928968e-003
18165, -1.782426e-001, 3.324840e-001, 6.928968e-003
18166, -1.787132e-001, 3.333676e-001, 6.928968e-003
18167, -1.791838e-001, 3.342511e-001, 6.928969e-003
18168, -1.796544e-001, 3.351346e-001, 6.928969e-003
18169, -1.801251e-001, 3.360181e-001, 6.928969e-003
18170, -1.805957e-001, 3.369016e-001, 6.928969e-003
18171, -1.810663e-001, 3.377851e-001, 6.928969e-003
18172, -1.815369e-001, 3.386686e-001, 6.928970e-003
18173, -1.820075e-001, 3.395522e-001, 6.928970e-003
18174, -1.824782e-001, 3.404357e-001, 6.928970e-003
18175, -1.829488e-001, 3.413192e-001, 6.928970e-003
18176, -1.834194e-001, 3.422027e-001, 6.928970e-003
18177, -1.838900e-001, 3.430862e-001, 6.928971e-003
18178, -1.843606e-001, 3.439697e-001, 6.928971e-003
18179, -1.848313e-001, 3.448533e-001, 6.928971e-003
18180, -1.853019e-001, 3.457368e-001, 6.928971e-003
18181, -1.857725e-001, 3.466203e-001, 6.928971e-003
18182, -1.862431e-001, 3.475038e-001, 6.928971e-003
18183, -1.867137e-001, 3.483873e-001, 6.928972e-003
18184, -1.871844e-001, 3.492708e-001, 6.928972e-003
18185, -1.876550e-001, 3.501543e-001, 6.928972e-003
18186, -1.881256e-001, 3.510379e-001, 6.928972e-003
18187, -1.885962e-001, 3.519214e-001, 6.928972e-003
18188, -1.890668e-001, 3.528049e-001, 6.928972e-003
18189, -1.895374e-001, 3.536884e-001, 6.928972e-003
18190, -1.900081e-001, 3.545719e-001, 6.928973e-003
18191, -1.904787e-001, 3.554554e-001, 6.928973e-003
18192, -1.909493e-001, 3.563390e-001, 6.928973e-003
18193, -1.914199e-001, 3.572225e-001, 6.928973e-003
18194, -1.918905e-001, 3.581060e-001, 6.928973e-003
18195, -1.923612e-001, 3.589895e-001, 6.928973e-003
18196, -1.928318e-001, 3.598730e-001, 6.928973e-003
18197, -1.933024e-001, 3.607565e-001, 6.928973e-003
18198, -1.937730e-001, 3.616401e-001, 6.928973e-003
18199, -1.942436e-001, 3.625236e-001, 6.928974e-003
18200, -1.947143e-001, 3.634071e-001, 6.928974e-003
18201, -1.951849e-001, 3.642906e-001, 6.928974e-003
18202, -1.956555e-001, 3.651741e-001, 6.928974e-003
18203, -1.961261e-001, 3.660576e-001, 6.928974e-003
18204, -1.965967e-001, 3.669412e-001, 6.928974e-003
18205, -1.970674e-001, 3.678247e-001, 6.928974e-003
18206, -1.975380e-001, 3.687082e-001, 6.928974e-003
18207, -1.980086e-001, 3.695917e-001, 6.928974e-003
18208, -1.984792e-001, 3.704752e-001, 6.928974e-003
18209, -1.989498e-001, 3.713587e-001, 6.928974e-003
18210, -1.994205e-001, 3.722423e-001, 6.928974e-003
18211, -1.998911e-001, 3.731258e-001, 6.928975e-003
18212, -2.003617e-001, 3.740093e-001, 6.928975e-003
18213, -2.008323e-001, 3.748928e-001, 6.928975e-003
18214, -2.013029e-001, 3.757763e-001, 6.928975e-003
18215, -2.017735e-001, 3.766598e-001, 6.928975e-003
18216, -2.022442e-001, 3.775434e-001, 6.928975e-003
18217, -2.027148e-001, 3.784269e-001, 6.928975e-003
18218, -2.031855e-001, 3.793106e-001, 6.928973e-003
18219, -2.036563e-001, 3.801946e-001, 6.928967e-003
18220, -2.041275e-001, 3.810794e-001, 6.928951e-003
18221, -2.045991e-001, 3.819651e-001, 6.928922e-003
18222, -2.050708e-001, 3.828514e-001, 6.928885e-003
18223, -2.055426e-001, 3.837377e-001, 6.928844e-003
18224, -2.060143e-001, 3.846237e-001, 6.928806e-003
18225, -2.064856e-001, 3.855088e-001, 6.928780e-003
18226, -2.069564e-001, 3.863929e-001, 6.928767e-003
18227, -2.074269e-001, 3.872764e-001, 6.928761e-003
18228, -2.078974e-001, 3.881597e-001, 6.928757e-003
18229, -2.083679e-001, 3.890430e-001, 6.928753e-003
18230, -2.088382e-001, 3.899259e-001, 6.928752e-003
18231, -2.093085e-001, 3.908089e-001, 6.928751e-003
18232, -2.097788e-001, 3.916920e-001, 6.928748e-003
18233, -2.102491e-001, 3.925748e-001, 6.928748e-003
18234, -2.107194e-001, 3.934577e-001, 6.928751e-003
18235, -2.111897e-001, 3.943405e-001, 6.928752e-003
18236, -2.116600e-001, 3.952235e-001, 6.928753e-003
18237, -2.121304e-001, 3.961066e-001, 6.928751e-003
18238, -2.126008e-001, 3.969897e-001, 6.928752e-003
18239, -2.130711e-001, 3.978726e-001, 6.928759e-003
18240, -2.135415e-001, 3.987554e-001, 6.928771e-003
18241, -2.140117e-001, 3.996380e-001, 6.928785e-003
18242, -2.144820e-001, 4.005207e-001, 6.928801e-003
18243, -2.110751e-001, 3.898908e-001, 6.928974e-003
18244, -2.091957e-001, 3.863624e-001, 6.928971e-003
18245, -2.096655e-001, 3.872445e-001, 6.928970e-003
18246, -1.429496e-001, 2.662278e-001, 6.928891e-003
18247, -2.134242e-001, 3.943009e-001, 6.928974e-003
18248, -2.138941e-001, 3.951830e-001, 6.928970e-003
18249, -2.077846e-001, 3.837126e-001, 6.928929e-003
18250, -2.073132e-001, 3.828272e-001, 6.928887e-003
18251, -2.068419e-001, 3.819417e-001, 6.928847e-003
18252, -2.063707e-001, 3.810566e-001, 6.928812e-003
18253, -2.058998e-001, 3.801721e-001, 6.928786e-003
18254, -2.054292e-001, 3.792883e-001, 6.928770e-003
18255, -2.049588e-001, 3.784051e-001, 6.928762e-003
18256, -2.044885e-001, 3.775223e-001, 6.928759e-003
18257, -2.040184e-001, 3.766396e-001, 6.928758e-003
18258, -2.035482e-001, 3.757569e-001, 6.928758e-003
18259, -2.030781e-001, 3.748743e-001, 6.928758e-003
18260, -2.026079e-001, 3.739917e-001, 6.928758e-003
18261, -2.021378e-001, 3.731091e-001, 6.928758e-003
18262, -2.016677e-001, 3.722265e-001, 6.928758e-003
18263, -2.011975e-001, 3.713439e-001, 6.928758e-003
18264, -2.007274e-001, 3.704613e-001, 6.928758e-003
18265, -2.002573e-001, 3.695787e-001, 6.928758e-003
18266, -1.997872e-001, 3.686962e-001, 6.928759e-003
18267, -1.993170e-001, 3.678136e-001, 6.928759e-003
18268, -1.988469e-001, 3.669310e-001, 6.928759e-003
18269, -1.983768e-001, 3.660484e-001, 6.928759e-003
18270, -1.979066e-001, 3.651658e-001, 6.928759e-003
18271, -1.974365e-001, 3.642832e-001, 6.928760e-003
18272, -1.969664e-001, 3.634006e-001, 6.928760e-003
18273, -1.964963e-001, 3.625180e-001, 6.928760e-003
18274, -1.960261e-001, 3.616354e-001, 6.928760e-003
18275, -1.955560e-001, 3.607528e-001, 6.928761e-003
18276, -1.950859e-001, 3.598702e-001, 6.928761e-003
18277, -1.946157e-001, 3.589876e-001, 6.928761e-003
18278, -1.941456e-001, 3.581050e-001, 6.928761e-003
18279, -1.936755e-001, 3.572224e-001, 6.928762e-003
18280, -1.932054e-001, 3.563398e-001, 6.928762e-003
18281, -1.927352e-001, 3.554573e-001, 6.928762e-003
18282, -1.922651e-001, 3.545747e-001, 6.928762e-003
18283, -1.917950e-001, 3.536921e-001, 6.928763e-003
18284, -1.913249e-001, 3.528095e-001, 6.928763e-003
18285, -1.908547e-001, 3.519269e-001, 6.928763e-003
18286, -1.903846e-001, 3.510443e-001, 6.928764e-003
18287, -1.899145e-001, 3.501617e-001, 6.928764e-003
18288, -1.894443e-001, 3.492791e-001, 6.928764e-003
18289, -1.889742e-001, 3.483965e-001, 6.928764e-003
18290, -1.885041e-001, 3.475139e-001, 6.928765e-003
18291, -1.880340e-001, 3.466314e-001, 6.928765e-003
18292, -1.875638e-001, 3.457488e-001, 6.928766e-003
18293, -1.870937e-001, 3.448662e-001, 6.928766e-003
18294, -1.866236e-001, 3.439836e-001, 6.928766e-003
18295, -1.861535e-001, 3.431010e-001, 6.928767e-003
18296, -1.856833e-001, 3.422184e-001, 6.928767e-003
18297, -1.852132e-001, 3.413358e-001, 6.928767e-003
18298, -1.847431e-001, 3.404532e-001, 6.928768e-003
18299, -1.842730e-001, 3.395707e-001, 6.928768e-003
18300, -1.838028e-001, 3.386881e-001, 6.928769e-003
18301, -1.833327e-001, 3.378055e-001, 6.928769e-003
18302, -1.828626e-001, 3.369229e-001, 6.928770e-003
18303, -1.823924e-001, 3.360403e-001, 6.928770e-003
18304, -1.819223e-001, 3.351577e-001, 6.928771e-003
18305, -1.814522e-001, 3.342751e-001, 6.928771e-003
18306, -1.809821e-001, 3.333926e-001, 6.928772e-003
18307, -1.805119e-001, 3.325100e-001, 6.928772e-003
18308, -1.800418e-001, 3.316274e-001, 6.928773e-003
18309, -1.795717e-001, 3.307448e-001, 6.928773e-003
18310, -1.791016e-001, 3.298622e-001, 6.928774e-003
18311, -1.786314e-001, 3.289796e-001, 6.928774e-003
18312, -1.781613e-001, 3.280971e-001, 6.928775e-003
18313, -1.776912e-001, 3.272145e-001, 6.928775e-003
18314, -1.772211e-001, 3.263319e-001, 6.928776e-003
18315, -1.767509e-001, 3.254493e-001, 6.928776e-003
18316, -1.762808e-001, 3.245667e-001, 6.928777e-003
18317, -1.758107e-001, 3.236842e-001, 6.928778e-003
18318, -1.753406e-001, 3.228016e-001, 6.928778e-003
18319, -1.748704e-001, 3.219190e-001, 6.928779e-003
18320, -1.744003e-001, 3.210364e-001, 6.928780e-003
18321, -1.739302e-001, 3.201538e-001, 6.928780e-003
18322, -1.734601e-001, 3.192713e-001, 6.928781e-003
18323, -1.729899e-001, 3.183887e-001, 6.928782e-003
18324, -1.725198e-001, 3.175061e-001, 6.928782e-003
18325, -1.720497e-001, 3.166235e-001, 6.928783e-003
18326, -1.715796e-001, 3.157409e-001, 6.928784e-003
18327, -1.711094e-001, 3.148584e-001, 6.928784e-003
18328, -1.706393e-001, 3.139758e-001, 6.928785e-003
18329, -1.701692e-001, 3.130932e-001, 6.928786e-003
18330, -1.696991e-001, 3.122106e-001, 6.928787e-003
18331, -1.692289e-001, 3.113281e-001, 6.928787e-003
18332, -1.687588e-001, 3.104455e-001, 6.928788e-003
18333, -1.682887e-001, 3.095629e-001, 6.928789e-003
18334, -1.678186e-001, 3.086803e-001, 6.928790e-003
18335, -1.673485e-001, 3.077977e-001, 6.928791e-003
18336, -1.668783e-001, 3.069152e-001, 6.928792e-003
18337, -1.664082e-001, 3.060326e-001, 6.928792e-003
18338, -1.659381e-001, 3.051500e-001, 6.928793e-003
18339, -1.654680e-001, 3.042674e-001, 6.928794e-003
18340, -1.649978e-001, 3.033849e-001, 6.928795e-003
18341, -1.645277e-001, 3.025023e-001, 6.928796e-003
18342, -1.640576e-001, 3.016197e-001, 6.928797e-003
18343, -1.635875e-001, 3.007372e-001, 6.928798e-003
18344, -1.631173e-001, 2.998546e-001, 6.928799e-003
18345, -1.626472e-001, 2.989720e-001, 6.928800e-003
18346, -1.621771e-001, 2.980894e-001, 6.928801e-003
18347, -1.617070e-001, 2.972069e-001, 6.928802e-003
18348, -1.612369e-001, 2.963243e-001, 6.928803e-003
18349, -1.607667e-001, 2.954417e-001, 6.928804e-003
18350, -1.602966e-001, 2.945592e-001, 6.928805e-003
18351, -1.598265e-001, 2.936766e-001, 6.928806e-003
18352, -1.593564e-001, 2.927940e-001, 6.928807e-003
18353, -1.588862e-001, 2.919114e-001, 6.928808e-003
18354, -1.584161e-001, 2.910289e-001, 6.928810e-003
18355, -1.579460e-001, 2.901463e-001, 6.928811e-003
18356, -1.574759e-001, 2.892637e-001, 6.928812e-003
18357, -1.570057e-001, 2.883812e-001, 6.928813e-003
18358, -1.565356e-001, 2.874986e-001, 6.928814e-003
18359, -1.560655e-001, 2.866160e-001, 6.928815e-003
18360, -1.555954e-001, 2.857335e-001, 6.928817e-003
18361, -1.551253e-001, 2.848509e-001, 6.928818e-003
18362, -1.546551e-001, 2.839683e-001, 6.928819e-003
18363, -1.541850e-001, 2.830858e-001, 6.928820e-003
18364, -1.537149e-001, 2.822032e-001, 6.928822e-003
18365, -1.532448e-001, 2.813206e-001, 6.928823e-003
18366, -1.527746e-001, 2.804381e-001, 6.928824e-003
18367, -1.523045e-001, 2.795555e-001, 6.928826e-003
18368, -1.518344e-001, 2.786729e-001, 6.928827e-003
18369, -1.513643e-001, 2.777904e-001, 6.928829e-003
18370, -1.508941e-001, 2.769078e-001, 6.928830e-003
18371, -1.504240e-001, 2.760252e-001, 6.928832e-003
18372, -1.499538e-001, 2.751425e-001, 6.928834e-003
18373, -1.494835e-001, 2.742597e-001, 6.928837e-003
18374, -1.490131e-001, 2.733766e-001, 6.928842e-003
18375, -1.485427e-001, 2.724936e-001, 6.928849e-003
18376, -1.480725e-001, 2.716109e-001, 6.928860e-003
18377, -1.476030e-001, 2.707297e-001, 6.928875e-003
18378, -1.471335e-001, 2.698486e-001, 6.928888e-003
18379, -1.466638e-001, 2.689670e-001, 6.928896e-003
18380, -1.461941e-001, 2.680851e-001, 6.928900e-003
18381, -1.457236e-001, 2.672019e-001, 6.928904e-003
18382, -1.452537e-001, 2.663199e-001, 6.928916e-003
18383, -1.447839e-001, 2.654392e-001, 6.928993e-003
18384, -1.443147e-001, 2.645621e-001, 6.929252e-003
18385, -1.438496e-001, 2.636967e-001, 6.929769e-003
18386, -1.433911e-001, 2.628490e-001, 6.930645e-003
18387, -1.429499e-001, 2.620379e-001, 6.931795e-003
18388, -1.426506e-001, 2.613304e-001, 6.921815e-003
18389, -1.419927e-001, 2.607938e-001, 6.963399e-003
18390, -2.167130e-001, 4.004734e-001, 6.928857e-003
18391, -2.157736e-001, 3.987108e-001, 6.928930e-003
18392, -2.162433e-001, 3.995920e-001, 6.928891e-003
18393, -2.153037e-001, 3.978290e-001, 6.928946e-003
18394, -1.415431e-001, 2.635839e-001, 6.929123e-003
18395, -1.412504e-001, 2.612971e-001, 6.997766e-003
18396, -2.068995e-001, 3.841683e-001, 7.000000e-003
18397, -2.073705e-001, 3.850531e-001, 7.000000e-003
18398, -2.078411e-001, 3.859367e-001, 7.000000e-003
18399, -2.083114e-001, 3.868196e-001, 7.000000e-003
18400, -1.448042e-001, 2.675929e-001, 7.000000e-003
18401, -1.443349e-001, 2.667119e-001, 7.000000e-003
18402, -2.106622e-001, 3.912331e-001, 7.000000e-003
18403, -2.111321e-001, 3.921154e-001, 7.000000e-003
18404, -2.153627e-001, 4.000565e-001, 7.000000e-003
18405, -2.092519e-001, 3.885855e-001, 7.000000e-003
18406, -2.097219e-001, 3.894678e-001, 7.000000e-003
18407, -1.471541e-001, 2.720038e-001, 7.000000e-003
18408, -1.466848e-001, 2.711229e-001, 7.000000e-003
18409, -2.130124e-001, 3.956452e-001, 7.000000e-003
18410, -2.134825e-001, 3.965278e-001, 7.000000e-003
18411, -1.420631e-001, 2.622426e-001, 6.999342e-003
18412, -2.116021e-001, 3.929977e-001, 7.000000e-003
18413, -2.120721e-001, 3.938800e-001, 7.000000e-003
18414, -2.064279e-001, 3.832823e-001, 7.000000e-003
18415, -1.433977e-001, 2.649511e-001, 7.000000e-003
18416, -1.429361e-001, 2.640762e-001, 6.999999e-003
18417, -1.462151e-001, 2.702413e-001, 7.000000e-003
18418, -1.457452e-001, 2.693593e-001, 7.000000e-003
18419, -1.476251e-001, 2.728878e-001, 7.000000e-003
18420, -1.480958e-001, 2.737715e-001, 7.000000e-003
18421, -1.485665e-001, 2.746550e-001, 7.000000e-003
18422, -1.490370e-001, 2.755383e-001, 7.000000e-003
18423, -1.495075e-001, 2.764215e-001, 7.000000e-003
18424, -1.499779e-001, 2.773046e-001, 7.000000e-003
18425, -1.504483e-001, 2.781877e-001, 7.000000e-003
18426, -1.509187e-001, 2.790708e-001, 7.000000e-003
18427, -1.513891e-001, 2.799538e-001, 7.000000e-003
18428, -1.518595e-001, 2.808369e-001, 7.000000e-003
18429, -1.523299e-001, 2.817199e-001, 7.000000e-003
18430, -1.528002e-001, 2.826030e-001, 7.000000e-003
18431, -1.532706e-001, 2.834861e-001, 7.000000e-003
18432, -1.537410e-001, 2.843691e-001, 7.000000e-003
18433, -1.542114e-001, 2.852522e-001, 7.000000e-003
18434, -1.546818e-001, 2.861352e-001, 7.000000e-003
18435, -1.551521e-001, 2.870183e-001, 7.000000e-003
18436, -1.556225e-001, 2.879013e-001, 7.000000e-003
18437, -1.560929e-001, 2.887844e-001, 7.000000e-003
18438, -1.565633e-001, 2.896675e-001, 7.000000e-003
18439, -1.570337e-001, 2.905505e-001, 7.000000e-003
18440, -1.575040e-001, 2.914336e-001, 7.000000e-003
18441, -1.579744e-001, 2.923166e-001, 7.000000e-003
18442, -1.584448e-001, 2.931997e-001, 7.000000e-003
18443, -1.589152e-001, 2.940827e-001, 7.000000e-003
18444, -1.593856e-001, 2.949658e-001, 7.000000e-003
18445, -1.598559e-001, 2.958489e-001, 7.000000e-003
18446, -1.603263e-001, 2.967319e-001, 7.000000e-003
18447, -1.607967e-001, 2.976150e-001, 7.000000e-003
18448, -1.612671e-001, 2.984980e-001, 7.000000e-003
18449, -1.617375e-001, 2.993811e-001, 7.000000e-003
18450, -1.622078e-001, 3.002641e-001, 7.000000e-003
18451, -1.626782e-001, 3.011472e-001, 7.000000e-003
18452, -1.631486e-001, 3.020303e-001, 7.000000e-003
18453, -1.636190e-001, 3.029133e-001, 7.000000e-003
18454, -1.640894e-001, 3.037964e-001, 7.000000e-003
18455, -1.645597e-001, 3.046794e-001, 7.000000e-003
18456, -1.650301e-001, 3.055625e-001, 7.000000e-003
18457, -1.655005e-001, 3.064456e-001, 7.000000e-003
18458, -1.659709e-001, 3.073286e-001, 7.000000e-003
18459, -1.664413e-001, 3.082117e-001, 7.000000e-003
18460, -1.669116e-001, 3.090947e-001, 7.000000e-003
18461, -1.673820e-001, 3.099778e-001, 7.000000e-003
18462, -1.678524e-001, 3.108609e-001, 7.000000e-003
18463, -1.683228e-001, 3.117439e-001, 7.000000e-003
18464, -1.687932e-001, 3.126270e-001, 7.000000e-003
18465, -1.692635e-001, 3.135100e-001, 7.000000e-003
18466, -1.697339e-001, 3.143931e-001, 7.000000e-003
18467, -1.702043e-001, 3.152762e-001, 7.000000e-003
18468, -1.706747e-001, 3.161592e-001, 7.000000e-003
18469, -1.711451e-001, 3.170423e-001, 7.000000e-003
18470, -1.716154e-001, 3.179254e-001, 7.000000e-003
18471, -1.720858e-001, 3.188084e-001, 7.000000e-003
18472, -1.725562e-001, 3.196915e-001, 7.000000e-003
18473, -1.730266e-001, 3.205745e-001, 7.000000e-003
18474, -1.734970e-001, 3.214576e-001, 7.000000e-003
18475, -1.739674e-001, 3.223407e-001, 7.000000e-003
18476, -1.744377e-001, 3.232237e-001, 7.000000e-003
18477, -1.749081e-001, 3.241068e-001, 7.000000e-003
18478, -1.753785e-001, 3.249899e-001, 7.000000e-003
18479, -1.758489e-001, 3.258729e-001, 7.000000e-003
18480, -1.763193e-001, 3.267560e-001, 7.000000e-003
18481, -1.767896e-001, 3.276391e-001, 7.000000e-003
18482, -1.772600e-001, 3.285221e-001, 7.000000e-003
18483, -1.777304e-001, 3.294052e-001, 7.000000e-003
18484, -1.782008e-001, 3.302882e-001, 7.000000e-003
18485, -1.786712e-001, 3.311713e-001, 7.000000e-003
18486, -1.791415e-001, 3.320544e-001, 7.000000e-003
18487, -1.796119e-001, 3.329374e-001, 7.000000e-003
18488, -1.800823e-001, 3.338205e-001, 7.000000e-003
18489, -1.805527e-001, 3.347036e-001, 7.000000e-003
18490, -1.810231e-001, 3.355866e-001, 7.000000e-003
18491, -1.814934e-001, 3.364697e-001, 7.000000e-003
18492, -1.819638e-001, 3.373528e-001, 7.000000e-003
18493, -1.824342e-001, 3.382358e-001, 7.000000e-003
18494, -1.829046e-001, 3.391189e-001, 7.000000e-003
18495, -1.833750e-001, 3.400020e-001, 7.000000e-003
18496, -1.838454e-001, 3.408850e-001, 7.000000e-003
18497, -1.843157e-001, 3.417681e-001, 7.000000e-003
18498, -1.847861e-001, 3.426512e-001, 7.000000e-003
18499, -1.852565e-001, 3.435342e-001, 7.000000e-003
18500, -1.857269e-001, 3.444173e-001, 7.000000e-003
18501, -1.861973e-001, 3.453004e-001, 7.000000e-003
18502, -1.866676e-001, 3.461834e-001, 7.000000e-003
18503, -1.871380e-001, 3.470665e-001, 7.000000e-003
18504, -1.876084e-001, 3.479496e-001, 7.000000e-003
18505, -1.880788e-001, 3.488326e-001, 7.000000e-003
18506, -1.885492e-001, 3.497157e-001, 7.000000e-003
18507, -1.890195e-001, 3.505988e-001, 7.000000e-003
18508, -1.894899e-001, 3.514818e-001, 7.000000e-003
18509, -1.899603e-001, 3.523649e-001, 7.000000e-003
18510, -1.904307e-001, 3.532480e-001, 7.000000e-003
18511, -1.909011e-001, 3.541310e-001, 7.000000e-003
18512, -1.913715e-001, 3.550141e-001, 7.000000e-003
18513, -1.918418e-001, 3.558972e-001, 7.000000e-003
18514, -1.923122e-001, 3.567803e-001, 7.000000e-003
18515, -1.927826e-001, 3.576633e-001, 7.000000e-003
18516, -1.932530e-001, 3.585464e-001, 7.000000e-003
18517, -1.937234e-001, 3.594295e-001, 7.000000e-003
18518, -1.941937e-001, 3.603125e-001, 7.000000e-003
18519, -1.946641e-001, 3.611956e-001, 7.000000e-003
18520, -1.951345e-001, 3.620787e-001, 7.000000e-003
18521, -1.956049e-001, 3.629617e-001, 7.000000e-003
18522, -1.960753e-001, 3.638448e-001, 7.000000e-003
18523, -1.965457e-001, 3.647279e-001, 7.000000e-003
18524, -1.970160e-001, 3.656110e-001, 7.000000e-003
18525, -1.974864e-001, 3.664940e-001, 7.000000e-003
18526, -1.979568e-001, 3.673771e-001, 7.000000e-003
18527, -1.984272e-001, 3.682602e-001, 7.000000e-003
18528, -1.988976e-001, 3.691432e-001, 7.000000e-003
18529, -1.993679e-001, 3.700263e-001, 7.000000e-003
18530, -1.998383e-001, 3.709094e-001, 7.000000e-003
18531, -2.003087e-001, 3.717925e-001, 7.000000e-003
18532, -2.007791e-001, 3.726755e-001, 7.000000e-003
18533, -2.012495e-001, 3.735586e-001, 7.000000e-003
18534, -2.017199e-001, 3.744417e-001, 7.000000e-003
18535, -2.021902e-001, 3.753248e-001, 7.000000e-003
18536, -2.026606e-001, 3.762078e-001, 7.000000e-003
18537, -2.031310e-001, 3.770909e-001, 7.000000e-003
18538, -2.036014e-001, 3.779741e-001, 7.000000e-003
18539, -2.040719e-001, 3.788574e-001, 7.000000e-003
18540, -2.045426e-001, 3.797412e-001, 7.000000e-003
18541, -2.050136e-001, 3.806257e-001, 7.000000e-003
18542, -2.054849e-001, 3.815109e-001, 7.000000e-003
18543, -2.059564e-001, 3.823966e-001, 7.000000e-003
18544, -2.087816e-001, 3.877023e-001, 7.000000e-003
18545, -2.101919e-001, 3.903502e-001, 7.000000e-003
18546, -2.125422e-001, 3.947624e-001, 7.000000e-003
18547, -2.139526e-001, 3.974102e-001, 7.000000e-003
18548, -2.144226e-001, 3.982923e-001, 7.000000e-003
18549, -2.148927e-001, 3.991744e-001, 7.000000e-003
18550, -1.452758e-001, 2.684782e-001, 7.000000e-003
18551, -1.438665e-001, 2.658325e-001, 7.000000e-003
18552, -1.424831e-001, 2.631906e-001, 6.999969e-003
18553, -1.326417e-001, 2.273860e-001, 1.290565e-003
18554, -1.324793e-001, 2.278496e-001, 2.294948e-003
18555, -1.322409e-001, 2.285074e-001, 3.212313e-003
18556, -1.320728e-001, 2.294717e-001, 3.916799e-003
18557, -1.320371e-001, 2.305885e-001, 4.398574e-003
18558, -1.322222e-001, 2.317853e-001, 4.636654e-003
18559, -1.326344e-001, 2.329483e-001, 4.649873e-003
18560, -1.332896e-001, 2.340298e-001, 4.406529e-003
18561, -1.340831e-001, 2.349504e-001, 3.919969e-003
18562, -1.350638e-001, 2.358803e-001, 3.071494e-003
18563, -1.357289e-001, 2.361872e-001, 1.861757e-003
18564, -1.324498e-001, 2.261882e-001, 8.342966e-004
18565, -1.188195e-001, 2.288046e-001, 9.990158e-004
18566, -1.190288e-001, 2.287626e-001, 1.977446e-003
18567, -1.193726e-001, 2.286936e-001, 2.914911e-003
18568, -1.198436e-001, 2.285991e-001, 3.792134e-003
18569, -1.204320e-001, 2.284809e-001, 4.591558e-003
18570, -1.211268e-001, 2.283415e-001, 5.297963e-003
18571, -1.219142e-001, 2.281836e-001, 5.896777e-003
18572, -1.227775e-001, 2.280105e-001, 6.374880e-003
18573, -1.236984e-001, 2.278259e-001, 6.722253e-003
18574, -1.246577e-001, 2.276336e-001, 6.931924e-003
18575, -1.256369e-001, 2.274381e-001, 6.999957e-003
18576, -1.266114e-001, 2.272427e-001, 6.925509e-003
18577, -1.275586e-001, 2.270537e-001, 6.712850e-003
18578, -1.284662e-001, 2.268719e-001, 6.366461e-003
18579, -1.293149e-001, 2.266979e-001, 5.893957e-003
18580, -1.300772e-001, 2.265347e-001, 5.314473e-003
18581, -1.307564e-001, 2.264950e-001, 4.653173e-003
18582, -1.313850e-001, 2.264390e-001, 3.833994e-003
18583, -1.318258e-001, 2.262283e-001, 2.987362e-003
18584, -1.323452e-001, 2.265016e-001, 1.725918e-003
18585, -1.190318e-001, 2.298103e-001, 1.000405e-003
18586, -1.192635e-001, 2.308117e-001, 1.001071e-003
18587, -1.195146e-001, 2.318085e-001, 1.001375e-003
18588, -1.197849e-001, 2.328002e-001, 1.001426e-003
18589, -1.200744e-001, 2.337864e-001, 1.001421e-003
18590, -1.203830e-001, 2.347667e-001, 1.001475e-003
18591, -1.207106e-001, 2.357409e-001, 1.001529e-003
18592, -1.210570e-001, 2.367085e-001, 1.001538e-003
18593, -1.214222e-001, 2.376693e-001, 1.001532e-003
18594, -1.218059e-001, 2.386228e-001, 1.001552e-003
18595, -1.222081e-001, 2.395686e-001, 1.001573e-003
18596, -1.226285e-001, 2.405065e-001, 1.001456e-003
18597, -1.230671e-001, 2.414361e-001, 1.000892e-003
18598, -1.235235e-001, 2.423571e-001, 9.993597e-004
18599, -1.237138e-001, 2.422603e-001, 1.977791e-003
18600, -1.240265e-001, 2.421014e-001, 2.915159e-003
18601, -1.244547e-001, 2.418837e-001, 3.792325e-003
18602, -1.249897e-001, 2.416116e-001, 4.591827e-003
18603, -1.256214e-001, 2.412897e-001, 5.298512e-003
18604, -1.263368e-001, 2.409246e-001, 5.897230e-003
18605, -1.271209e-001, 2.405242e-001, 6.375152e-003
18606, -1.279579e-001, 2.400965e-001, 6.722627e-003
18607, -1.288291e-001, 2.396469e-001, 6.932381e-003
18608, -1.297159e-001, 2.391791e-001, 6.999927e-003
18609, -1.305940e-001, 2.387146e-001, 6.924528e-003
18610, -1.314296e-001, 2.382944e-001, 6.719866e-003
18611, -1.322073e-001, 2.378612e-001, 6.393559e-003
18612, -1.329527e-001, 2.374420e-001, 5.939524e-003
18613, -1.336549e-001, 2.370520e-001, 5.356115e-003
18614, -1.342599e-001, 2.366873e-001, 4.673653e-003
18615, -1.347750e-001, 2.364377e-001, 3.943420e-003
18616, -1.321248e-001, 2.270424e-001, 2.711652e-003
18617, -1.316366e-001, 2.276410e-001, 3.854420e-003
18618, -1.313990e-001, 2.289432e-001, 4.579862e-003
18619, -1.312857e-001, 2.303045e-001, 5.084483e-003
18620, -1.314631e-001, 2.317614e-001, 5.332931e-003
18621, -1.319300e-001, 2.332372e-001, 5.385844e-003
18622, -1.328244e-001, 2.346094e-001, 5.109400e-003
18623, -1.337653e-001, 2.357420e-001, 4.708861e-003
18624, -1.192408e-001, 2.297641e-001, 1.980059e-003
18625, -1.195840e-001, 2.296883e-001, 2.918252e-003
18626, -1.200537e-001, 2.295847e-001, 3.795571e-003
18627, -1.206403e-001, 2.294552e-001, 4.594731e-003
18628, -1.213334e-001, 2.293024e-001, 5.301315e-003
18629, -1.221197e-001, 2.291293e-001, 5.900581e-003
18630, -1.229821e-001, 2.289395e-001, 6.378721e-003
18631, -1.239019e-001, 2.287372e-001, 6.725432e-003
18632, -1.248620e-001, 2.285275e-001, 6.934057e-003
18633, -1.258382e-001, 2.283128e-001, 6.999880e-003
18634, -1.267991e-001, 2.280993e-001, 6.924497e-003
18635, -1.277280e-001, 2.278855e-001, 6.714582e-003
18636, -1.286160e-001, 2.276943e-001, 6.377015e-003
18637, -1.294558e-001, 2.275258e-001, 5.915136e-003
18638, -1.301669e-001, 2.273073e-001, 5.374717e-003
18639, -1.308122e-001, 2.274915e-001, 4.822248e-003
18640, -1.194719e-001, 2.307615e-001, 1.981329e-003
18641, -1.197221e-001, 2.317544e-001, 1.981949e-003
18642, -1.199914e-001, 2.327423e-001, 1.981923e-003
18643, -1.202797e-001, 2.337245e-001, 1.981834e-003
18644, -1.205870e-001, 2.347007e-001, 1.982019e-003
18645, -1.209133e-001, 2.356707e-001, 1.982173e-003
18646, -1.212582e-001, 2.366343e-001, 1.982163e-003
18647, -1.216218e-001, 2.375910e-001, 1.982128e-003
18648, -1.220040e-001, 2.385405e-001, 1.982192e-003
18649, -1.224045e-001, 2.394825e-001, 1.982263e-003
18650, -1.228233e-001, 2.404166e-001, 1.982026e-003
18651, -1.232599e-001, 2.413427e-001, 1.980888e-003
18652, -1.235761e-001, 2.411894e-001, 2.918824e-003
18653, -1.240089e-001, 2.409793e-001, 3.796023e-003
18654, -1.245493e-001, 2.407165e-001, 4.595350e-003
18655, -1.251875e-001, 2.404048e-001, 5.302197e-003
18656, -1.259105e-001, 2.400500e-001, 5.901319e-003
18657, -1.267030e-001, 2.396608e-001, 6.379215e-003
18658, -1.275478e-001, 2.392429e-001, 6.725953e-003
18659, -1.284235e-001, 2.387947e-001, 6.934403e-003
18660, -1.293102e-001, 2.383178e-001, 6.999822e-003
18661, -1.301978e-001, 2.378507e-001, 6.920476e-003
18662, -1.310096e-001, 2.375427e-001, 6.732321e-003
18663, -1.317013e-001, 2.370933e-001, 6.443456e-003
18664, -1.323945e-001, 2.366301e-001, 6.026825e-003
18665, -1.330784e-001, 2.361819e-001, 5.467972e-003
18666, -1.305817e-001, 2.284814e-001, 5.259735e-003
18667, -1.302981e-001, 2.300368e-001, 5.785929e-003
18668, -1.305292e-001, 2.317582e-001, 5.972936e-003
18669, -1.310407e-001, 2.337208e-001, 6.080716e-003
18670, -1.322633e-001, 2.351589e-001, 5.708237e-003
18671, -1.198139e-001, 2.306792e-001, 2.919902e-003
18672, -1.202820e-001, 2.305668e-001, 3.797175e-003
18673, -1.208662e-001, 2.304266e-001, 4.596066e-003
18674, -1.215569e-001, 2.302613e-001, 5.302737e-003
18675, -1.223411e-001, 2.300740e-001, 5.902324e-003
18676, -1.232013e-001, 2.298683e-001, 6.380626e-003
18677, -1.241220e-001, 2.296498e-001, 6.727935e-003
18678, -1.250848e-001, 2.294228e-001, 6.936139e-003
18679, -1.260557e-001, 2.291879e-001, 6.999780e-003
18680, -1.270067e-001, 2.289317e-001, 6.922298e-003
18681, -1.278995e-001, 2.286786e-001, 6.717875e-003
18682, -1.287360e-001, 2.284983e-001, 6.405617e-003
18683, -1.296224e-001, 2.284530e-001, 5.945416e-003
18684, -1.206166e-001, 2.336235e-001, 2.920054e-003
18685, -1.203303e-001, 2.326477e-001, 2.920483e-003
18686, -1.209221e-001, 2.345929e-001, 2.920650e-003
18687, -1.212460e-001, 2.355557e-001, 2.921026e-003
18688, -1.215883e-001, 2.365120e-001, 2.920881e-003
18689, -1.219493e-001, 2.374619e-001, 2.920740e-003
18690, -1.223289e-001, 2.384050e-001, 2.920929e-003
18691, -1.227268e-001, 2.393407e-001, 2.921154e-003
18692, -1.231428e-001, 2.402689e-001, 2.920863e-003
18693, -1.235796e-001, 2.400665e-001, 3.797979e-003
18694, -1.247673e-001, 2.395101e-001, 5.303609e-003
18695, -1.241248e-001, 2.398122e-001, 4.597507e-003
18696, -1.254960e-001, 2.391646e-001, 5.903046e-003
18697, -1.262938e-001, 2.387855e-001, 6.380561e-003
18698, -1.271397e-001, 2.383749e-001, 6.726107e-003
18699, -1.280085e-001, 2.379252e-001, 6.933619e-003
18700, -1.288947e-001, 2.374185e-001, 6.999785e-003
18701, -1.298748e-001, 2.367989e-001, 6.895805e-003
18702, -1.306941e-001, 2.369008e-001, 6.735454e-003
18703, -1.316830e-001, 2.357664e-001, 6.186298e-003
18704, -1.200629e-001, 2.316659e-001, 2.921000e-003
18705, -1.295606e-001, 2.293877e-001, 6.117164e-003
18706, -1.294529e-001, 2.317795e-001, 6.490745e-003
18707, -1.307243e-001, 2.349919e-001, 6.457914e-003
18708, -1.207942e-001, 2.325192e-001, 3.797532e-003
18709, -1.205291e-001, 2.315454e-001, 3.798250e-003
18710, -1.211109e-001, 2.313955e-001, 4.596789e-003
18711, -1.217990e-001, 2.312189e-001, 5.303433e-003
18712, -1.225804e-001, 2.310183e-001, 5.903151e-003
18713, -1.234399e-001, 2.307976e-001, 6.382503e-003
18714, -1.243663e-001, 2.305653e-001, 6.731635e-003
18715, -1.253319e-001, 2.303203e-001, 6.938813e-003
18716, -1.263115e-001, 2.300508e-001, 6.999390e-003
18717, -1.272603e-001, 2.297328e-001, 6.914479e-003
18718, -1.280812e-001, 2.294133e-001, 6.718327e-003
18719, -1.287563e-001, 2.292282e-001, 6.472553e-003
18720, -1.210785e-001, 2.334867e-001, 3.797768e-003
18721, -1.213810e-001, 2.344466e-001, 3.798166e-003
18722, -1.223965e-001, 2.372839e-001, 3.797878e-003
18723, -1.220396e-001, 2.363438e-001, 3.798309e-003
18724, -1.227729e-001, 2.382181e-001, 3.798460e-003
18725, -1.231676e-001, 2.391456e-001, 3.799071e-003
18726, -1.258940e-001, 2.379021e-001, 6.378651e-003
18727, -1.250957e-001, 2.382701e-001, 5.903137e-003
18728, -1.267324e-001, 2.375032e-001, 6.721387e-003
18729, -1.243639e-001, 2.386060e-001, 5.304877e-003
18730, -1.237169e-001, 2.389000e-001, 4.598429e-003
18731, -1.275784e-001, 2.370688e-001, 6.927298e-003
18732, -1.284046e-001, 2.365920e-001, 6.999753e-003
18733, -1.291649e-001, 2.360744e-001, 6.948941e-003
18734, -1.304100e-001, 2.358994e-001, 6.691003e-003
18735, -1.217017e-001, 2.353986e-001, 3.799010e-003
18736, -1.294113e-001, 2.305654e-001, 6.352384e-003
18737, -1.311348e-001, 2.363788e-001, 6.528962e-003
18738, -1.295672e-001, 2.346806e-001, 6.778811e-003
18739, -1.219543e-001, 2.342662e-001, 4.597038e-003
18740, -1.216557e-001, 2.333184e-001, 4.597045e-003
18741, -1.233260e-001, 2.379814e-001, 4.598001e-003
18742, -1.287277e-001, 2.353193e-001, 6.961927e-003
18743, -1.279637e-001, 2.357873e-001, 6.998291e-003
18744, -1.213745e-001, 2.323604e-001, 4.597342e-003
18745, -1.220600e-001, 2.321736e-001, 5.303878e-003
18746, -1.228391e-001, 2.319598e-001, 5.904195e-003
18747, -1.237013e-001, 2.317260e-001, 6.385903e-003
18748, -1.246286e-001, 2.314806e-001, 6.734928e-003
18749, -1.255998e-001, 2.312255e-001, 6.941363e-003
18750, -1.266091e-001, 2.309397e-001, 6.998501e-003
18751, -1.276014e-001, 2.305508e-001, 6.895400e-003
18752, -1.283469e-001, 2.300776e-001, 6.692819e-003
18753, -1.286692e-001, 2.307001e-001, 6.648407e-003
18754, -1.271638e-001, 2.362263e-001, 6.919097e-003
18755, -1.263367e-001, 2.366369e-001, 6.713456e-003
18756, -1.226024e-001, 2.361326e-001, 4.597184e-003
18757, -1.222705e-001, 2.352032e-001, 4.598081e-003
18758, -1.229545e-001, 2.370576e-001, 4.598031e-003
18759, -1.255091e-001, 2.370193e-001, 6.374172e-003
18760, -1.247131e-001, 2.373736e-001, 5.901811e-003
18761, -1.239781e-001, 2.376968e-001, 5.305137e-003
18762, -1.296228e-001, 2.334953e-001, 6.638473e-003
18763, -1.297244e-001, 2.355688e-001, 6.824864e-003
18764, -1.288235e-001, 2.343173e-001, 6.899152e-003
18765, -1.282667e-001, 2.346624e-001, 6.979097e-003
18766, -1.281973e-001, 2.329980e-001, 6.921708e-003
18767, -1.275393e-001, 2.350130e-001, 6.995013e-003
18768, -1.267750e-001, 2.354135e-001, 6.909579e-003
18769, -1.259671e-001, 2.357930e-001, 6.704628e-003
18770, -1.223390e-001, 2.331203e-001, 5.304415e-003
18771, -1.231162e-001, 2.328925e-001, 5.905860e-003
18772, -1.281965e-001, 2.315612e-001, 6.839685e-003
18773, -1.239729e-001, 2.326460e-001, 6.386210e-003
18774, -1.248856e-001, 2.323978e-001, 6.731262e-003
18775, -1.258530e-001, 2.321634e-001, 6.938292e-003
18776, -1.269223e-001, 2.319363e-001, 6.998139e-003
18777, -1.236118e-001, 2.367871e-001, 5.304529e-003
18778, -1.290499e-001, 2.297991e-001, 6.414494e-003
18779, -1.232671e-001, 2.358812e-001, 5.303976e-003
18780, -1.229424e-001, 2.349721e-001, 5.304518e-003
18781, -1.243527e-001, 2.364817e-001, 5.900494e-003
18782, -1.251486e-001, 2.361496e-001, 6.369176e-003
18783, -1.226340e-001, 2.340528e-001, 5.305343e-003
18784, -1.279845e-001, 2.340069e-001, 6.981670e-003
18785, -1.271244e-001, 2.341829e-001, 6.990622e-003
18786, -1.264227e-001, 2.346290e-001, 6.900801e-003
18787, -1.256286e-001, 2.349717e-001, 6.696806e-003
18788, -1.248140e-001, 2.352910e-001, 6.365306e-003
18789, -1.240146e-001, 2.355973e-001, 5.898961e-003
18790, -1.234034e-001, 2.338090e-001, 5.904781e-003
18791, -1.242398e-001, 2.335506e-001, 6.378184e-003
18792, -1.251132e-001, 2.333057e-001, 6.714756e-003
18793, -1.260213e-001, 2.331117e-001, 6.920100e-003
18794, -1.270614e-001, 2.330535e-001, 6.999826e-003
18795, -1.236998e-001, 2.347089e-001, 5.900838e-003
18796, -1.245100e-001, 2.344328e-001, 6.366600e-003
18797, -1.253256e-001, 2.341719e-001, 6.691973e-003
18798, -1.260738e-001, 2.339713e-001, 6.881775e-003
18799, -1.252782e-001, 2.256590e-001, 6.999999e-003
18800, -1.262995e-001, 2.254551e-001, 6.922622e-003
18801, -1.274060e-001, 2.251950e-001, 6.654185e-003
18802, -1.282423e-001, 2.244825e-001, 6.264888e-003
18803, -1.289345e-001, 2.241775e-001, 5.840846e-003
18804, -1.296530e-001, 2.237542e-001, 5.240883e-003
18805, -1.302947e-001, 2.231990e-001, 4.489665e-003
18806, -1.306087e-001, 2.219647e-001, 3.768507e-003
18807, -1.308013e-001, 2.209692e-001, 3.121534e-003
18808, -1.306722e-001, 2.196321e-001, 2.888670e-003
18809, -1.304952e-001, 2.185217e-001, 2.836924e-003
18810, -1.302853e-001, 2.174578e-001, 2.875864e-003
18811, -1.300347e-001, 2.163723e-001, 2.992144e-003
18812, -1.297150e-001, 2.153584e-001, 3.261173e-003
18813, -1.294015e-001, 2.144061e-001, 3.512920e-003
18814, -1.290747e-001, 2.134763e-001, 3.769510e-003
18815, -1.287225e-001, 2.125540e-001, 4.040970e-003
18816, -1.283356e-001, 2.116400e-001, 4.333276e-003
18817, -1.279154e-001, 2.107650e-001, 4.641879e-003
18818, -1.274593e-001, 2.098967e-001, 4.954366e-003
18819, -1.269506e-001, 2.090458e-001, 5.280016e-003
18820, -1.263753e-001, 2.082289e-001, 5.618807e-003
18821, -1.257406e-001, 2.074352e-001, 5.947602e-003
18822, -1.250424e-001, 2.066969e-001, 6.258449e-003
18823, -1.243147e-001, 2.062432e-001, 6.538321e-003
18824, -1.235354e-001, 2.056558e-001, 6.754483e-003
18825, -1.223769e-001, 2.054826e-001, 6.962003e-003
18826, -1.215469e-001, 2.056765e-001, 6.998922e-003
18827, -1.207000e-001, 2.058491e-001, 6.930065e-003
18828, -1.201489e-001, 2.063692e-001, 6.809547e-003
18829, -1.191146e-001, 2.069564e-001, 6.439780e-003
18830, -1.186776e-001, 2.078661e-001, 6.154089e-003
18831, -1.183363e-001, 2.087329e-001, 5.862095e-003
18832, -1.180571e-001, 2.096621e-001, 5.550150e-003
18833, -1.178016e-001, 2.106374e-001, 5.196148e-003
18834, -1.176223e-001, 2.115774e-001, 4.864084e-003
18835, -1.174733e-001, 2.125246e-001, 4.515304e-003
18836, -1.174284e-001, 2.135170e-001, 4.240198e-003
18837, -1.173935e-001, 2.144752e-001, 3.956863e-003
18838, -1.172701e-001, 2.153638e-001, 3.514578e-003
18839, -1.173086e-001, 2.165678e-001, 3.191972e-003
18840, -1.174288e-001, 2.176802e-001, 3.031864e-003
18841, -1.175646e-001, 2.187315e-001, 2.918453e-003
18842, -1.177175e-001, 2.197588e-001, 2.847228e-003
18843, -1.179018e-001, 2.207870e-001, 2.844203e-003
18844, -1.181439e-001, 2.218379e-001, 2.957073e-003
18845, -1.184960e-001, 2.229171e-001, 3.268439e-003
18846, -1.189704e-001, 2.237932e-001, 3.799683e-003
18847, -1.194443e-001, 2.245540e-001, 4.268543e-003
18848, -1.200489e-001, 2.253764e-001, 4.795646e-003
18849, -1.210562e-001, 2.255364e-001, 5.647173e-003
18850, -1.219613e-001, 2.256634e-001, 6.190213e-003
18851, -1.230010e-001, 2.259309e-001, 6.613925e-003
18852, -1.242372e-001, 2.258188e-001, 6.919860e-003
18853, -1.283866e-001, 2.038679e-001, 9.919009e-004
18854, -1.285614e-001, 2.048295e-001, 9.841353e-004
18855, -1.287345e-001, 2.057870e-001, 9.831832e-004
18856, -1.289070e-001, 2.067574e-001, 1.002941e-003
18857, -1.290809e-001, 2.077336e-001, 1.019044e-003
18858, -1.292626e-001, 2.087205e-001, 9.961634e-004
18859, -1.294431e-001, 2.096966e-001, 9.672539e-004
18860, -1.296251e-001, 2.106822e-001, 9.387027e-004
18861, -1.298083e-001, 2.116406e-001, 8.622240e-004
18862, -1.299733e-001, 2.124934e-001, 7.705341e-004
18863, -1.300967e-001, 2.135240e-001, 1.204364e-003
18864, -1.302514e-001, 2.142274e-001, 1.036687e-003
18865, -1.305726e-001, 2.157880e-001, 7.329226e-004
18866, -1.306804e-001, 2.165114e-001, 9.226555e-004
18867, -1.308484e-001, 2.174836e-001, 9.767804e-004
18868, -1.310307e-001, 2.184911e-001, 9.747643e-004
18869, -1.312170e-001, 2.195005e-001, 9.468785e-004
18870, -1.314031e-001, 2.204526e-001, 8.390496e-004
18871, -1.316048e-001, 2.216500e-001, 9.509395e-004
18872, -1.317429e-001, 2.224786e-001, 1.030518e-003
18873, -1.319103e-001, 2.234043e-001, 1.029538e-003
18874, -1.320858e-001, 2.243646e-001, 1.015597e-003
18875, -1.281791e-001, 2.038955e-001, 1.959077e-003
18876, -1.278427e-001, 2.039548e-001, 2.883044e-003
18877, -1.273890e-001, 2.040656e-001, 3.747208e-003
18878, -1.268089e-001, 2.041984e-001, 4.551800e-003
18879, -1.261167e-001, 2.043490e-001, 5.267553e-003
18880, -1.253061e-001, 2.045232e-001, 5.890742e-003
18881, -1.244276e-001, 2.045629e-001, 6.366514e-003
18882, -1.236825e-001, 2.045648e-001, 6.653102e-003
18883, -1.220101e-001, 2.048308e-001, 6.983298e-003
18884, -1.213125e-001, 2.049447e-001, 6.996430e-003
18885, -1.203444e-001, 2.051506e-001, 6.894151e-003
18886, -1.195367e-001, 2.051799e-001, 6.704372e-003
18887, -1.186530e-001, 2.053509e-001, 6.365157e-003
18888, -1.178098e-001, 2.054085e-001, 5.909026e-003
18889, -1.172816e-001, 2.058293e-001, 5.486356e-003
18890, -1.163656e-001, 2.059180e-001, 4.613503e-003
18891, -1.157509e-001, 2.060605e-001, 3.775003e-003
18892, -1.152626e-001, 2.062509e-001, 2.814578e-003
18893, -1.148906e-001, 2.062763e-001, 1.742040e-003
18894, -1.146800e-001, 2.059896e-001, 9.440314e-004
18895, -1.184603e-001, 2.268636e-001, 1.009518e-003
18896, -1.182975e-001, 2.259498e-001, 1.024843e-003
18897, -1.181361e-001, 2.250391e-001, 1.045045e-003
18898, -1.179720e-001, 2.240983e-001, 1.082731e-003
18899, -1.177962e-001, 2.230833e-001, 1.129082e-003
18900, -1.175859e-001, 2.219916e-001, 1.047509e-003
18901, -1.173917e-001, 2.209532e-001, 1.003195e-003
18902, -1.172065e-001, 2.199399e-001, 9.885368e-004
18903, -1.170254e-001, 2.189400e-001, 9.855040e-004
18904, -1.168449e-001, 2.179593e-001, 9.619497e-004
18905, -1.166662e-001, 2.170516e-001, 8.514427e-004
18906, -1.164784e-001, 2.158853e-001, 1.018695e-003
18907, -1.163522e-001, 2.150802e-001, 1.140037e-003
18908, -1.161916e-001, 2.141506e-001, 1.182900e-003
18909, -1.160235e-001, 2.131819e-001, 1.221590e-003
18910, -1.158526e-001, 2.122072e-001, 1.250218e-003
18911, -1.156814e-001, 2.112460e-001, 1.263449e-003
18912, -1.155065e-001, 2.102630e-001, 1.277724e-003
18913, -1.153079e-001, 2.092407e-001, 1.201426e-003
18914, -1.151194e-001, 2.082365e-001, 1.160315e-003
18915, -1.149477e-001, 2.072381e-001, 1.210128e-003
18916, -1.186811e-001, 2.268726e-001, 1.990115e-003
18917, -1.190283e-001, 2.268296e-001, 2.920036e-003
18918, -1.194985e-001, 2.267014e-001, 3.803834e-003
18919, -1.201404e-001, 2.265044e-001, 4.675437e-003
18920, -1.209349e-001, 2.264355e-001, 5.431674e-003
18921, -1.217372e-001, 2.264142e-001, 5.989961e-003
18922, -1.224249e-001, 2.264919e-001, 6.343714e-003
18923, -1.282540e-001, 2.252218e-001, 6.323232e-003
18924, -1.290738e-001, 2.250327e-001, 5.850711e-003
18925, -1.298338e-001, 2.248234e-001, 5.251679e-003
18926, -1.304909e-001, 2.246489e-001, 4.565917e-003
18927, -1.310483e-001, 2.245790e-001, 3.818440e-003
18928, -1.315168e-001, 2.244753e-001, 2.953787e-003
18929, -1.318691e-001, 2.244017e-001, 2.007285e-003
18930, -1.309170e-001, 2.236028e-001, 3.749446e-003
18931, -1.311244e-001, 2.225712e-001, 3.054053e-003
18932, -1.313132e-001, 2.209966e-001, 1.801070e-003
18933, -1.310346e-001, 2.196306e-001, 1.914814e-003
18934, -1.308264e-001, 2.185072e-001, 1.933065e-003
18935, -1.306231e-001, 2.174077e-001, 1.948910e-003
18936, -1.303926e-001, 2.161140e-001, 1.937949e-003
18937, -1.300166e-001, 2.150330e-001, 2.473133e-003
18938, -1.297150e-001, 2.140939e-001, 2.792954e-003
18939, -1.294157e-001, 2.131637e-001, 3.072760e-003
18940, -1.290960e-001, 2.122161e-001, 3.355378e-003
18941, -1.287326e-001, 2.112466e-001, 3.674299e-003
18942, -1.283389e-001, 2.103779e-001, 4.027809e-003
18943, -1.279204e-001, 2.094802e-001, 4.364310e-003
18944, -1.274377e-001, 2.085743e-001, 4.731382e-003
18945, -1.268699e-001, 2.077214e-001, 5.140115e-003
18946, -1.262513e-001, 2.068272e-001, 5.522000e-003
18947, -1.254935e-001, 2.057673e-001, 5.914158e-003
18948, -1.243441e-001, 2.054372e-001, 6.469836e-003
18949, -1.280325e-001, 2.048711e-001, 2.829711e-003
18950, -1.283558e-001, 2.048327e-001, 1.934018e-003
18951, -1.177760e-001, 2.075727e-001, 5.621770e-003
18952, -1.175287e-001, 2.083479e-001, 5.317807e-003
18953, -1.173476e-001, 2.093188e-001, 4.996259e-003
18954, -1.170738e-001, 2.103334e-001, 4.510999e-003
18955, -1.169419e-001, 2.112366e-001, 4.142035e-003
18956, -1.167202e-001, 2.121396e-001, 3.569284e-003
18957, -1.168258e-001, 2.132488e-001, 3.406955e-003
18958, -1.169079e-001, 2.141609e-001, 3.256689e-003
18959, -1.166614e-001, 2.152880e-001, 2.218232e-003
18960, -1.167749e-001, 2.165378e-001, 1.855119e-003
18961, -1.170290e-001, 2.177617e-001, 1.969437e-003
18962, -1.172196e-001, 2.188263e-001, 1.963621e-003
18963, -1.174015e-001, 2.198584e-001, 1.948126e-003
18964, -1.175964e-001, 2.208996e-001, 1.971067e-003
18965, -1.178289e-001, 2.220000e-001, 2.081037e-003
18966, -1.181882e-001, 2.233576e-001, 2.412119e-003
18967, -1.186983e-001, 2.242104e-001, 3.209329e-003
18968, -1.190225e-001, 2.249671e-001, 3.544292e-003
18969, -1.193080e-001, 2.257887e-001, 3.764536e-003
18970, -1.285244e-001, 2.057481e-001, 1.922800e-003
18971, -1.286807e-001, 2.067171e-001, 1.986126e-003
18972, -1.288361e-001, 2.076929e-001, 2.054516e-003
18973, -1.290476e-001, 2.087186e-001, 1.968394e-003
18974, -1.292439e-001, 2.096855e-001, 1.894194e-003
18975, -1.294337e-001, 2.107209e-001, 1.884637e-003
18976, -1.296602e-001, 2.117357e-001, 1.725441e-003
18977, -1.298734e-001, 2.126556e-001, 1.532077e-003
18978, -1.299440e-001, 2.137811e-001, 2.028494e-003
18979, -1.301838e-001, 2.146194e-001, 1.715192e-003
18980, -1.304147e-001, 2.152771e-001, 1.196604e-003
18981, -1.315041e-001, 2.223873e-001, 2.010764e-003
18982, -1.316860e-001, 2.234187e-001, 2.025140e-003
18983, -1.276301e-001, 2.050475e-001, 3.646395e-003
18984, -1.270786e-001, 2.052416e-001, 4.456574e-003
18985, -1.263939e-001, 2.054018e-001, 5.191348e-003
18986, -1.196021e-001, 2.058347e-001, 6.688531e-003
18987, -1.188052e-001, 2.061073e-001, 6.372173e-003
18988, -1.179064e-001, 2.061994e-001, 5.879809e-003
18989, -1.172498e-001, 2.066575e-001, 5.339983e-003
18990, -1.165437e-001, 2.068154e-001, 4.631305e-003
18991, -1.159372e-001, 2.069906e-001, 3.803022e-003
18992, -1.154143e-001, 2.073799e-001, 2.694386e-003
18993, -1.185293e-001, 2.260140e-001, 2.001009e-003
18994, -1.188669e-001, 2.259902e-001, 2.899083e-003
18995, -1.183811e-001, 2.251807e-001, 2.008879e-003
18996, -1.182495e-001, 2.243359e-001, 2.076657e-003
18997, -1.164851e-001, 2.142030e-001, 2.275295e-003
18998, -1.163354e-001, 2.132113e-001, 2.357949e-003
18999, -1.161790e-001, 2.122329e-001, 2.413403e-003
19000, -1.160113e-001, 2.113280e-001, 2.401914e-003
19001, -1.159153e-001, 2.103444e-001, 2.611506e-003
19002, -1.155863e-001, 2.091941e-001, 2.292710e-003
19003, -1.153738e-001, 2.082337e-001, 2.178923e-003
19004, -1.313335e-001, 2.234970e-001, 2.967598e-003
19005, -1.230200e-001, 2.049383e-001, 6.846479e-003
19006, -1.274624e-001, 2.064285e-001, 4.246620e-003
19007, -1.279481e-001, 2.060056e-001, 3.401808e-003
19008, -1.296857e-001, 2.128802e-001, 2.316236e-003
19009, -1.294106e-001, 2.119172e-001, 2.582670e-003
19010, -1.290626e-001, 2.107988e-001, 2.918608e-003
19011, -1.286972e-001, 2.100247e-001, 3.360662e-003
19012, -1.283355e-001, 2.090985e-001, 3.688768e-003
19013, -1.278948e-001, 2.081068e-001, 4.074662e-003
19014, -1.273506e-001, 2.072884e-001, 4.570656e-003
19015, -1.267941e-001, 2.063352e-001, 4.975755e-003
19016, -1.168442e-001, 2.079145e-001, 4.742626e-003
19017, -1.167793e-001, 2.090188e-001, 4.443559e-003
19018, -1.166893e-001, 2.098694e-001, 4.134530e-003
19019, -1.165046e-001, 2.102944e-001, 3.757812e-003
19020, -1.163743e-001, 2.114330e-001, 3.179120e-003
19021, -1.186927e-001, 2.252272e-001, 2.819050e-003
19022, -1.282109e-001, 2.056569e-001, 2.747102e-003
19023, -1.283138e-001, 2.066370e-001, 2.912109e-003
19024, -1.283070e-001, 2.075583e-001, 3.259156e-003
19025, -1.287010e-001, 2.087730e-001, 2.909238e-003
19026, -1.289408e-001, 2.096422e-001, 2.724087e-003
19027, -1.161826e-001, 2.079218e-001, 3.917868e-003
19028, -1.157698e-001, 2.081058e-001, 3.172478e-003
19029, -1.161526e-001, 2.098455e-001, 3.301773e-003
19030, -1.159205e-001, 2.090132e-001, 3.146682e-003
19031, -1.185355e-001, 2.245981e-001, 2.719693e-003
19032, -1.162932e-001, 2.088925e-001, 3.821823e-003
19033, -1.178977e-001, 2.068563e-001, 5.796946e-003
19034, -1.163693e-001, 2.095492e-001, 3.756698e-003
19035, -1.164368e-001, 2.108618e-001, 3.480414e-003
*element, elset=S3,type=S3
1643, 2781, 2791, 2778, 
1703, 2533, 2381, 2291, 
1772, 2672, 2689, 2716, 
1831, 2568, 2493, 2494, 
2019, 2421, 2476, 2475, 
2110, 2790, 2742, 2731, 
2184, 1, 1623, 120, 
2220, 2757, 2745, 2746, 
2222, 119, 120, 1684, 
2248, 2221, 2132, 2133, 
2249, 1622, 1847, 1623, 
2263, 2743, 2741, 2761, 
2275, 1753, 1847, 1752, 
2328, 2626, 2562, 2633, 
2330, 2680, 2688, 2728, 
2333, 1702, 60, 1624, 
2450, 2330, 2408, 2329, 
2460, 1900, 2020, 1899, 
2509, 2215, 2313, 2214, 
2529, 2023, 2024, 2134, 
2564, 1998, 2112, 2055, 
2592, 1877, 1997, 1878, 
2620, 1701, 1702, 1829, 
2720, 2442, 2496, 2515, 
2774, 18889, 18888, 18988, 
2790, 18923, 18801, 18802, 
2805, 2417, 2481, 2408, 
2884, 1585, 1586, 18915, 
2893, 1552, 1553, 18862, 
2894, 19007, 19022, 19023, 
2895, 2668, 2657, 2630, 
2897, 18948, 18823, 18824, 
2898, 2612, 2615, 2657, 
2899, 2683, 2682, 2703, 
2900, 2706, 2718, 2675, 
2903, 19011, 19026, 19010, 
2904, 19006, 19014, 19015, 
2905, 19033, 18951, 18989, 
2907, 2758, 2716, 2720, 
2909, 18992, 19028, 19003, 
2916, 18886, 18885, 18986, 
2920, 18881, 18948, 18882, 
2921, 2774, 2780, 2773, 
2922, 18837, 18838, 18958, 
2923, 19004, 18930, 18931, 
2924, 2777, 2789, 2784, 
2926, 18806, 18807, 18931, 
3865, 3404, 3431, 3403, 
3901, 3665, 3666, 3685, 
3916, 3506, 3572, 3505, 
3918, 3702, 3707, 3705, 
11151, 11198, 11199, 11204, 
11359, 11185, 11186, 11207, 
11453, 11082, 11130, 11093, 
11513, 11028, 11029, 11092, 
11542, 10624, 10666, 10690, 
11571, 11059, 11099, 11058, 
11599, 10823, 10833, 10807, 
11699, 18828, 18827, 1094, 
11701, 11182, 11172, 11173, 
11731, 11592, 11471, 11591, 
11732, 11809, 11852, 11811, 
11961, 11549, 11548, 11665, 
12155, 508, 11246, 507, 
12229, 11812, 11813, 11844, 
12269, 11731, 11732, 11835, 
12300, 11768, 11826, 11769, 
12314, 11752, 11753, 11817, 
12326, 11734, 11735, 11806, 
12336, 11720, 11721, 11801, 
12350, 11681, 11771, 11682, 
12360, 11554, 11553, 11671, 
12362, 11267, 11268, 11395, 
12401, 11592, 11588, 11470, 
12406, 11513, 11632, 11512, 
12411, 11590, 11657, 11616, 
12413, 11637, 11615, 11497, 
12419, 11667, 11723, 11668, 
12421, 11686, 11762, 11659, 
12422, 11699, 11738, 11700, 
12429, 1575, 1576, 18905, 
12430, 11788, 11785, 11620, 
12432, 11760, 11802, 11727, 
12434, 1560, 1561, 18870, 
12435, 11726, 11787, 11743, 
12436, 11818, 11793, 11794, 
12438, 18952, 19016, 18951, 
12440, 11827, 11861, 11803, 
12441, 11823, 11838, 11824, 
12443, 11850, 11839, 11840, 
12448, 19018, 18954, 19019, 
12449, 11851, 11863, 11840, 
12452, 12713, 573, 11866, 
12597, 12842, 12844, 13083, 
12599, 12437, 12436, 12438, 
12893, 12698, 12697, 12959, 
13022, 12156, 843, 12155, 
13042, 13303, 13302, 13323, 
13307, 12965, 13201, 12849, 
13316, 12962, 12845, 13197, 
13432, 12852, 12847, 13089, 
13557, 12724, 12725, 12975, 
13562, 12722, 12716, 12970, 
13571, 12572, 12965, 12711, 
13683, 12437, 12706, 12454, 
13798, 12445, 12446, 12717, 
13809, 12713, 574, 573, 
13925, 12167, 12168, 12449, 
14035, 12297, 12027, 12298, 
14038, 711, 712, 12025, 
14041, 698, 699, 12012, 
14045, 714, 8, 12011, 
14046, 12311, 12569, 12310, 
14049, 12434, 12451, 12435, 
14061, 12440, 12709, 12712, 
14066, 12582, 12569, 12568, 
14067, 12701, 12719, 12702, 
14070, 13085, 12580, 12581, 
14075, 12844, 12835, 12834, 
14089, 13206, 13322, 12969, 
14091, 13207, 13083, 13082, 
14093, 13320, 13313, 13312, 
14109, 13, 936, 948, 
14199, 858, 857, 13345, 
14282, 14185, 14184, 14263, 
14379, 14032, 14263, 14117, 
14634, 14109, 14261, 14110, 
14640, 14102, 14101, 14254, 
14804, 13873, 14033, 13872, 
14878, 13700, 13873, 13699, 
15031, 13614, 13782, 13613, 
15112, 13876, 13694, 13952, 
15122, 13516, 13693, 13692, 
15125, 13777, 13866, 13778, 
15130, 14116, 14112, 13950, 
15133, 14114, 14192, 14037, 
15135, 14031, 13790, 13948, 
15136, 14261, 14262, 14113, 
15213, 14324, 14325, 14342, 
15223, 14299, 14326, 14298, 
15239, 14314, 14334, 14313, 
15245, 14350, 14344, 14349, 
15247, 14368, 569, 570, 
15249, 14397, 14375, 14374, 
15264, 1079, 1078, 14365, 
15294, 1073, 1072, 14359, 
15312, 1080, 14366, 1081, 
15314, 14379, 14382, 14380, 
15316, 14393, 14369, 14368, 
15318, 1067, 1066, 14353, 
15321, 1065, 11, 14351, 
15323, 849, 14414, 848, 
15324, 14402, 1083, 1082, 
15337, 1088, 1087, 14407, 
15351, 14410, 852, 853, 
15355, 14411, 14416, 14413, 
15361, 490, 14459, 489, 
15394, 14445, 1094, 14444, 
15395, 14527, 14536, 14572, 
15433, 14460, 14503, 14461, 
15485, 14570, 14575, 14599, 
15488, 14559, 14520, 14573, 
15492, 14524, 14558, 14525, 
15502, 14470, 14553, 14510, 
15528, 14469, 14441, 14439, 
15541, 14427, 14475, 14428, 
15554, 526, 14425, 525, 
15570, 14446, 14491, 14447, 
15577, 14465, 14513, 14466, 
15589, 14504, 14545, 14505, 
15593, 14475, 14515, 14476, 
15598, 14530, 14537, 14493, 
15601, 14516, 14579, 14515, 
15612, 14593, 14626, 14601, 
15613, 14629, 14591, 14611, 
15616, 14627, 14631, 14617, 
15639, 15466, 15865, 15866, 
16859, 18387, 18411, 18388, 
17272, 18395, 18074, 18389, 
17642, 1504, 14656, 11, 
17667, 17757, 17753, 18085, 
18022, 17378, 17746, 17014, 
18049, 15093, 15468, 15092, 
18391, 15056, 15467, 15076, 
18419, 15498, 15869, 15497, 
18423, 1119, 1120, 14676, 
18766, 1100, 1099, 14657, 
18779, 17738, 17379, 17380, 
19433, 16637, 17009, 16662, 
19753, 17011, 17023, 16650, 
19754, 17012, 17399, 17033, 
19757, 17388, 17401, 17575, 
19758, 17393, 17735, 17408, 
19759, 17583, 17746, 17411, 
19761, 17735, 18071, 17734, 
19762, 17754, 18073, 17753, 
19776, 18786, 18798, 18785, 
19834, 1525, 1526, 18583, 
19891, 1506, 1505, 18564, 
19936, 18563, 1121, 1120, 
20024, 18614, 18623, 18615, 
20036, 18639, 18666, 18638, 
20059, 18778, 18719, 18705, 
20060, 18738, 18764, 18762, 
20061, 18765, 18784, 18764, 
*element, elset=S4R,type=S4R
1606, 24, 1587, 42, 3, 
1607, 25, 1588, 1587, 24, 
1608, 26, 1589, 1588, 25, 
1609, 27, 1590, 1589, 26, 
1610, 28, 1591, 1590, 27, 
1611, 29, 1592, 1591, 28, 
1612, 30, 1593, 1592, 29, 
1613, 31, 1594, 1593, 30, 
1614, 32, 1595, 1594, 31, 
1615, 33, 1596, 1595, 32, 
1616, 34, 1597, 1596, 33, 
1617, 35, 1598, 1597, 34, 
1618, 36, 1599, 1598, 35, 
1619, 37, 1600, 1599, 36, 
1620, 38, 1601, 1600, 37, 
1621, 39, 1602, 1601, 38, 
1622, 40, 1603, 1602, 39, 
1623, 41, 1604, 1603, 40, 
1624, 2, 1605, 1604, 41, 
1625, 42, 1587, 1606, 43, 
1626, 43, 1606, 1607, 44, 
1627, 44, 1607, 1608, 45, 
1628, 45, 1608, 1609, 46, 
1629, 46, 1609, 1610, 47, 
1630, 47, 1610, 1611, 48, 
1631, 48, 1611, 1612, 49, 
1632, 49, 1612, 1613, 50, 
1633, 50, 1613, 1614, 51, 
1634, 51, 1614, 1615, 52, 
1635, 52, 1615, 1616, 53, 
1636, 53, 1616, 1617, 54, 
1637, 54, 1617, 1618, 55, 
1638, 55, 1618, 1619, 56, 
1639, 56, 1619, 1620, 57, 
1640, 57, 1620, 1621, 58, 
1641, 58, 1621, 1622, 59, 
1642, 59, 1622, 1623, 1, 
1644, 2777, 2785, 2786, 2789, 
1645, 62, 1626, 1625, 61, 
1646, 63, 1627, 1626, 62, 
1647, 64, 1628, 1627, 63, 
1648, 65, 1629, 1628, 64, 
1649, 66, 1630, 1629, 65, 
1650, 67, 1631, 1630, 66, 
1651, 68, 1632, 1631, 67, 
1652, 69, 1633, 1632, 68, 
1653, 70, 1634, 1633, 69, 
1654, 71, 1635, 1634, 70, 
1655, 72, 1636, 1635, 71, 
1656, 73, 1637, 1636, 72, 
1657, 74, 1638, 1637, 73, 
1658, 75, 1639, 1638, 74, 
1659, 76, 1640, 1639, 75, 
1660, 77, 1641, 1640, 76, 
1661, 78, 1642, 1641, 77, 
1662, 79, 1643, 1642, 78, 
1663, 80, 1644, 1643, 79, 
1664, 81, 1645, 1644, 80, 
1665, 82, 1646, 1645, 81, 
1666, 83, 1647, 1646, 82, 
1667, 84, 1648, 1647, 83, 
1668, 85, 1649, 1648, 84, 
1669, 86, 1650, 1649, 85, 
1670, 87, 1651, 1650, 86, 
1671, 88, 1652, 1651, 87, 
1672, 89, 1653, 1652, 88, 
1673, 90, 1654, 1653, 89, 
1674, 91, 1655, 1654, 90, 
1675, 92, 1656, 1655, 91, 
1676, 93, 1657, 1656, 92, 
1677, 94, 1658, 1657, 93, 
1678, 95, 1659, 1658, 94, 
1679, 96, 1660, 1659, 95, 
1680, 97, 1661, 1660, 96, 
1681, 98, 1662, 1661, 97, 
1682, 99, 1663, 1662, 98, 
1683, 100, 1664, 1663, 99, 
1684, 101, 1665, 1664, 100, 
1685, 102, 1666, 1665, 101, 
1686, 103, 1667, 1666, 102, 
1687, 104, 1668, 1667, 103, 
1688, 105, 1669, 1668, 104, 
1689, 106, 1670, 1669, 105, 
1690, 107, 1671, 1670, 106, 
1691, 108, 1672, 1671, 107, 
1692, 109, 1673, 1672, 108, 
1693, 110, 1674, 1673, 109, 
1694, 111, 1675, 1674, 110, 
1695, 112, 1676, 1675, 111, 
1696, 113, 1677, 1676, 112, 
1697, 114, 1678, 1677, 113, 
1698, 115, 1679, 1678, 114, 
1699, 116, 1680, 1679, 115, 
1700, 117, 1681, 1680, 116, 
1701, 118, 1682, 1681, 117, 
1702, 119, 1683, 1682, 118, 
1704, 42, 1685, 138, 3, 
1705, 43, 1686, 1685, 42, 
1706, 44, 1687, 1686, 43, 
1707, 45, 1688, 1687, 44, 
1708, 46, 1689, 1688, 45, 
1709, 47, 1690, 1689, 46, 
1710, 48, 1691, 1690, 47, 
1711, 49, 1692, 1691, 48, 
1712, 50, 1693, 1692, 49, 
1713, 51, 1694, 1693, 50, 
1714, 52, 1695, 1694, 51, 
1715, 53, 1696, 1695, 52, 
1716, 54, 1697, 1696, 53, 
1717, 55, 1698, 1697, 54, 
1718, 56, 1699, 1698, 55, 
1719, 57, 1700, 1699, 56, 
1720, 58, 1701, 1700, 57, 
1721, 59, 1702, 1701, 58, 
1722, 121, 1703, 1605, 2, 
1723, 122, 1704, 1703, 121, 
1724, 123, 1705, 1704, 122, 
1725, 124, 1706, 1705, 123, 
1726, 125, 1707, 1706, 124, 
1727, 126, 1708, 1707, 125, 
1728, 127, 1709, 1708, 126, 
1729, 128, 1710, 1709, 127, 
1730, 129, 1711, 1710, 128, 
1731, 130, 1712, 1711, 129, 
1732, 131, 1713, 1712, 130, 
1733, 132, 1714, 1713, 131, 
1734, 133, 1715, 1714, 132, 
1735, 134, 1716, 1715, 133, 
1736, 135, 1717, 1716, 134, 
1737, 136, 1718, 1717, 135, 
1738, 137, 1719, 1718, 136, 
1739, 138, 1685, 1719, 137, 
1740, 1588, 1720, 1606, 1587, 
1741, 1589, 1721, 1720, 1588, 
1742, 1590, 1722, 1721, 1589, 
1743, 1591, 1723, 1722, 1590, 
1744, 1592, 1724, 1723, 1591, 
1745, 1593, 1725, 1724, 1592, 
1746, 1594, 1726, 1725, 1593, 
1747, 1595, 1727, 1726, 1594, 
1748, 1596, 1728, 1727, 1595, 
1749, 1597, 1729, 1728, 1596, 
1750, 1598, 1730, 1729, 1597, 
1751, 1599, 1731, 1730, 1598, 
1752, 1600, 1732, 1731, 1599, 
1753, 1601, 1733, 1732, 1600, 
1754, 1602, 1734, 1733, 1601, 
1755, 1603, 1735, 1734, 1602, 
1756, 1604, 1736, 1735, 1603, 
1757, 1605, 1737, 1736, 1604, 
1758, 1607, 1739, 1738, 1608, 
1759, 1608, 1738, 1740, 1609, 
1760, 1609, 1740, 1741, 1610, 
1761, 1610, 1741, 1742, 1611, 
1762, 1611, 1742, 1743, 1612, 
1763, 1612, 1743, 1744, 1613, 
1764, 1613, 1744, 1745, 1614, 
1765, 1614, 1745, 1746, 1615, 
1766, 1615, 1746, 1747, 1616, 
1767, 1616, 1747, 1748, 1617, 
1768, 1617, 1748, 1749, 1618, 
1769, 1618, 1749, 1750, 1619, 
1770, 1619, 1750, 1751, 1620, 
1771, 1620, 1751, 1752, 1621, 
1773, 2672, 2716, 2758, 2731, 
1774, 1627, 1757, 1756, 1626, 
1775, 1628, 1758, 1757, 1627, 
1776, 1629, 1759, 1758, 1628, 
1777, 1630, 1760, 1759, 1629, 
1778, 1631, 1761, 1760, 1630, 
1779, 1632, 1762, 1761, 1631, 
1780, 1633, 1763, 1762, 1632, 
1781, 1634, 1764, 1763, 1633, 
1782, 1635, 1765, 1764, 1634, 
1783, 1636, 1766, 1765, 1635, 
1784, 1637, 1767, 1766, 1636, 
1785, 1638, 1768, 1767, 1637, 
1786, 1639, 1769, 1768, 1638, 
1787, 1640, 1770, 1769, 1639, 
1788, 1641, 1771, 1770, 1640, 
1789, 1642, 1772, 1771, 1641, 
1790, 1643, 1773, 1772, 1642, 
1791, 1644, 1774, 1773, 1643, 
1792, 1645, 1775, 1774, 1644, 
1793, 1646, 1776, 1775, 1645, 
1794, 1647, 1777, 1776, 1646, 
1795, 1648, 1778, 1777, 1647, 
1796, 1649, 1779, 1778, 1648, 
1797, 1650, 1780, 1779, 1649, 
1798, 1651, 1781, 1780, 1650, 
1799, 1652, 1782, 1781, 1651, 
1800, 1653, 1783, 1782, 1652, 
1801, 1654, 1784, 1783, 1653, 
1802, 1655, 1785, 1784, 1654, 
1803, 1656, 1786, 1785, 1655, 
1804, 1657, 1787, 1786, 1656, 
1805, 1658, 1788, 1787, 1657, 
1806, 1659, 1789, 1788, 1658, 
1807, 1660, 1790, 1789, 1659, 
1808, 1661, 1791, 1790, 1660, 
1809, 1662, 1792, 1791, 1661, 
1810, 1663, 1793, 1792, 1662, 
1811, 1664, 1794, 1793, 1663, 
1812, 1665, 1795, 1794, 1664, 
1813, 1666, 1796, 1795, 1665, 
1814, 1667, 1797, 1796, 1666, 
1815, 1668, 1798, 1797, 1667, 
1816, 1669, 1799, 1798, 1668, 
1817, 1670, 1800, 1799, 1669, 
1818, 1671, 1801, 1800, 1670, 
1819, 1672, 1802, 1801, 1671, 
1820, 1673, 1803, 1802, 1672, 
1821, 1674, 1804, 1803, 1673, 
1822, 1675, 1805, 1804, 1674, 
1823, 1676, 1806, 1805, 1675, 
1824, 1677, 1807, 1806, 1676, 
1825, 1678, 1808, 1807, 1677, 
1826, 1679, 1809, 1808, 1678, 
1827, 1680, 1810, 1809, 1679, 
1828, 1681, 1811, 1810, 1680, 
1829, 1682, 1812, 1811, 1681, 
1830, 1683, 1813, 1812, 1682, 
1832, 1686, 1814, 1719, 1685, 
1833, 1687, 1815, 1814, 1686, 
1834, 1688, 1816, 1815, 1687, 
1835, 1689, 1817, 1816, 1688, 
1836, 1690, 1818, 1817, 1689, 
1837, 1691, 1819, 1818, 1690, 
1838, 1692, 1820, 1819, 1691, 
1839, 1693, 1821, 1820, 1692, 
1840, 1694, 1822, 1821, 1693, 
1841, 1695, 1823, 1822, 1694, 
1842, 1696, 1824, 1823, 1695, 
1843, 1697, 1825, 1824, 1696, 
1844, 1698, 1826, 1825, 1697, 
1845, 1699, 1827, 1826, 1698, 
1846, 1700, 1828, 1827, 1699, 
1847, 1701, 1829, 1828, 1700, 
1848, 2568, 2494, 2558, 2563, 
1849, 1703, 1830, 1737, 1605, 
1850, 1704, 1831, 1830, 1703, 
1851, 1705, 1832, 1831, 1704, 
1852, 1706, 1833, 1832, 1705, 
1853, 1707, 1834, 1833, 1706, 
1854, 1708, 1835, 1834, 1707, 
1855, 1709, 1836, 1835, 1708, 
1856, 1710, 1837, 1836, 1709, 
1857, 1711, 1838, 1837, 1710, 
1858, 1712, 1839, 1838, 1711, 
1859, 1713, 1840, 1839, 1712, 
1860, 1714, 1841, 1840, 1713, 
1861, 1715, 1842, 1841, 1714, 
1862, 1716, 1843, 1842, 1715, 
1863, 1717, 1844, 1843, 1716, 
1864, 1718, 1845, 1844, 1717, 
1865, 1719, 1814, 1845, 1718, 
1866, 1606, 1720, 1739, 1607, 
1867, 1626, 1756, 1846, 1625, 
1868, 120, 1623, 1847, 1684, 
1869, 1721, 1848, 1739, 1720, 
1870, 1722, 1849, 1848, 1721, 
1871, 1723, 1850, 1849, 1722, 
1872, 1724, 1851, 1850, 1723, 
1873, 1725, 1852, 1851, 1724, 
1874, 1726, 1853, 1852, 1725, 
1875, 1727, 1854, 1853, 1726, 
1876, 1728, 1855, 1854, 1727, 
1877, 1729, 1856, 1855, 1728, 
1878, 1730, 1857, 1856, 1729, 
1879, 1731, 1858, 1857, 1730, 
1880, 1732, 1859, 1858, 1731, 
1881, 1733, 1860, 1859, 1732, 
1882, 1734, 1861, 1860, 1733, 
1883, 1735, 1862, 1861, 1734, 
1884, 1736, 1863, 1862, 1735, 
1885, 1737, 1864, 1863, 1736, 
1886, 1739, 1848, 1865, 1738, 
1887, 1738, 1865, 1866, 1740, 
1888, 1742, 1868, 1867, 1743, 
1889, 1743, 1867, 1869, 1744, 
1890, 1744, 1869, 1870, 1745, 
1891, 1745, 1870, 1871, 1746, 
1892, 1746, 1871, 1872, 1747, 
1893, 1747, 1872, 1873, 1748, 
1894, 1748, 1873, 1874, 1749, 
1895, 1749, 1874, 1875, 1750, 
1896, 1750, 1875, 1876, 1751, 
1897, 1751, 1876, 1877, 1752, 
1898, 1752, 1877, 1878, 1753, 
1899, 1755, 1880, 1879, 1754, 
1900, 1759, 1882, 1881, 1758, 
1901, 1760, 1883, 1882, 1759, 
1902, 1761, 1884, 1883, 1760, 
1903, 1762, 1885, 1884, 1761, 
1904, 1763, 1886, 1885, 1762, 
1905, 1764, 1887, 1886, 1763, 
1906, 1765, 1888, 1887, 1764, 
1907, 1766, 1889, 1888, 1765, 
1908, 1767, 1890, 1889, 1766, 
1909, 1768, 1891, 1890, 1767, 
1910, 1769, 1892, 1891, 1768, 
1911, 1770, 1893, 1892, 1769, 
1912, 1771, 1894, 1893, 1770, 
1913, 1772, 1895, 1894, 1771, 
1914, 1773, 1896, 1895, 1772, 
1915, 1774, 1897, 1896, 1773, 
1916, 1775, 1898, 1897, 1774, 
1917, 1776, 1899, 1898, 1775, 
1918, 1777, 1900, 1899, 1776, 
1919, 1778, 1901, 1900, 1777, 
1920, 1779, 1902, 1901, 1778, 
1921, 1780, 1903, 1902, 1779, 
1922, 1781, 1904, 1903, 1780, 
1923, 1782, 1905, 1904, 1781, 
1924, 1783, 1906, 1905, 1782, 
1925, 1784, 1907, 1906, 1783, 
1926, 1785, 1908, 1907, 1784, 
1927, 1786, 1909, 1908, 1785, 
1928, 1787, 1910, 1909, 1786, 
1929, 1788, 1911, 1910, 1787, 
1930, 1789, 1912, 1911, 1788, 
1931, 1790, 1913, 1912, 1789, 
1932, 1791, 1914, 1913, 1790, 
1933, 1792, 1915, 1914, 1791, 
1934, 1793, 1916, 1915, 1792, 
1935, 1794, 1917, 1916, 1793, 
1936, 1795, 1918, 1917, 1794, 
1937, 1796, 1919, 1918, 1795, 
1938, 1797, 1920, 1919, 1796, 
1939, 1798, 1921, 1920, 1797, 
1940, 1799, 1922, 1921, 1798, 
1941, 1800, 1923, 1922, 1799, 
1942, 1801, 1924, 1923, 1800, 
1943, 1802, 1925, 1924, 1801, 
1944, 1803, 1926, 1925, 1802, 
1945, 1804, 1927, 1926, 1803, 
1946, 1805, 1928, 1927, 1804, 
1947, 1806, 1929, 1928, 1805, 
1948, 1807, 1930, 1929, 1806, 
1949, 1808, 1931, 1930, 1807, 
1950, 1809, 1932, 1931, 1808, 
1951, 1810, 1933, 1932, 1809, 
1952, 1811, 1934, 1933, 1810, 
1953, 1812, 1935, 1934, 1811, 
1954, 1813, 1936, 1935, 1812, 
1955, 1740, 1866, 1937, 1741, 
1956, 1815, 1938, 1845, 1814, 
1957, 1816, 1939, 1938, 1815, 
1958, 1817, 1940, 1939, 1816, 
1959, 1818, 1941, 1940, 1817, 
1960, 1819, 1942, 1941, 1818, 
1961, 1820, 1943, 1942, 1819, 
1962, 1821, 1944, 1943, 1820, 
1963, 1822, 1945, 1944, 1821, 
1964, 1823, 1946, 1945, 1822, 
1965, 1824, 1947, 1946, 1823, 
1966, 1825, 1948, 1947, 1824, 
1967, 1826, 1949, 1948, 1825, 
1968, 1827, 1950, 1949, 1826, 
1969, 1828, 1951, 1950, 1827, 
1970, 2533, 2291, 2193, 2216, 
1971, 1830, 1952, 1864, 1737, 
1972, 1831, 1953, 1952, 1830, 
1973, 1832, 1954, 1953, 1831, 
1974, 1833, 1955, 1954, 1832, 
1975, 1834, 1956, 1955, 1833, 
1976, 1835, 1957, 1956, 1834, 
1977, 1836, 1958, 1957, 1835, 
1978, 1837, 1959, 1958, 1836, 
1979, 1838, 1960, 1959, 1837, 
1980, 1839, 1961, 1960, 1838, 
1981, 1840, 1962, 1961, 1839, 
1982, 1841, 1963, 1962, 1840, 
1983, 1842, 1964, 1963, 1841, 
1984, 1843, 1965, 1964, 1842, 
1985, 1844, 1966, 1965, 1843, 
1986, 1845, 1938, 1966, 1844, 
1987, 1741, 1937, 1868, 1742, 
1988, 1756, 1968, 1967, 1846, 
1989, 1757, 1969, 1968, 1756, 
1990, 1758, 1881, 1969, 1757, 
1991, 1967, 1880, 1755, 1846, 
1992, 1753, 1878, 1936, 1813, 
1993, 1849, 1970, 1865, 1848, 
1994, 1850, 1971, 1970, 1849, 
1995, 1851, 1972, 1971, 1850, 
1996, 1852, 1973, 1972, 1851, 
1997, 1853, 1974, 1973, 1852, 
1998, 1854, 1975, 1974, 1853, 
1999, 1855, 1976, 1975, 1854, 
2000, 1856, 1977, 1976, 1855, 
2001, 1857, 1978, 1977, 1856, 
2002, 1858, 1979, 1978, 1857, 
2003, 1859, 1980, 1979, 1858, 
2004, 1860, 1981, 1980, 1859, 
2005, 1861, 1982, 1981, 1860, 
2006, 1862, 1983, 1982, 1861, 
2007, 1863, 1984, 1983, 1862, 
2008, 1864, 1985, 1984, 1863, 
2009, 1869, 1987, 1986, 1870, 
2010, 1868, 1989, 1988, 1867, 
2011, 1865, 1970, 1990, 1866, 
2012, 1867, 1988, 1987, 1869, 
2013, 1871, 1992, 1991, 1872, 
2014, 1872, 1991, 1993, 1873, 
2015, 1873, 1993, 1994, 1874, 
2016, 1874, 1994, 1995, 1875, 
2017, 1875, 1995, 1996, 1876, 
2018, 1876, 1996, 1997, 1877, 
2020, 1880, 2000, 1999, 1879, 
2021, 1967, 2001, 2000, 1880, 
2022, 1938, 1939, 2002, 1966, 
2023, 1866, 1990, 2003, 1937, 
2024, 1884, 2005, 2004, 1883, 
2025, 1885, 2006, 2005, 1884, 
2026, 1886, 2007, 2006, 1885, 
2027, 1887, 2008, 2007, 1886, 
2028, 1888, 2009, 2008, 1887, 
2029, 1889, 2010, 2009, 1888, 
2030, 1890, 2011, 2010, 1889, 
2031, 1891, 2012, 2011, 1890, 
2032, 1892, 2013, 2012, 1891, 
2033, 1893, 2014, 2013, 1892, 
2034, 1894, 2015, 2014, 1893, 
2035, 1895, 2016, 2015, 1894, 
2036, 1896, 2017, 2016, 1895, 
2037, 1897, 2018, 2017, 1896, 
2038, 1898, 2019, 2018, 1897, 
2039, 1899, 2020, 2019, 1898, 
2040, 1901, 2021, 2020, 1900, 
2041, 1902, 2022, 2021, 1901, 
2042, 1903, 2023, 2022, 1902, 
2043, 1904, 2024, 2023, 1903, 
2044, 1905, 2025, 2024, 1904, 
2045, 1906, 2026, 2025, 1905, 
2046, 1907, 2027, 2026, 1906, 
2047, 1908, 2028, 2027, 1907, 
2048, 1909, 2029, 2028, 1908, 
2049, 1910, 2030, 2029, 1909, 
2050, 1911, 2031, 2030, 1910, 
2051, 1912, 2032, 2031, 1911, 
2052, 1913, 2033, 2032, 1912, 
2053, 1914, 2034, 2033, 1913, 
