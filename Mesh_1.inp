15556, -1.536921e-001, 2.978219e-001, 2.908431e-003
15557, -1.541631e-001, 2.987060e-001, 2.908431e-003
15558, -1.546340e-001, 2.995902e-001, 2.908431e-003
15559, -1.551050e-001, 3.004743e-001, 2.908431e-003
15560, -1.555759e-001, 3.013584e-001, 2.908431e-003
15561, -1.560469e-001, 3.022426e-001, 2.908431e-003
15562, -1.565178e-001, 3.031267e-001, 2.908431e-003
15563, -1.569888e-001, 3.040109e-001, 2.908431e-003
15564, -1.574597e-001, 3.048950e-001, 2.908431e-003
15565, -1.579307e-001, 3.057791e-001, 2.908431e-003
15566, -1.584016e-001, 3.066633e-001, 2.908431e-003
15567, -1.588726e-001, 3.075474e-001, 2.908431e-003
15568, -1.593435e-001, 3.084316e-001, 2.908431e-003
15569, -1.598145e-001, 3.093157e-001, 2.908431e-003
15570, -1.602854e-001, 3.101999e-001, 2.908431e-003
15571, -1.607564e-001, 3.110840e-001, 2.908431e-003
15572, -1.612273e-001, 3.119681e-001, 2.908431e-003
15573, -1.616983e-001, 3.128523e-001, 2.908431e-003
15574, -1.621692e-001, 3.137364e-001, 2.908431e-003
15575, -1.626402e-001, 3.146206e-001, 2.908431e-003
15576, -1.631111e-001, 3.155047e-001, 2.908431e-003
15577, -1.635821e-001, 3.163888e-001, 2.908431e-003
15578, -1.640530e-001, 3.172730e-001, 2.908431e-003
15579, -1.645240e-001, 3.181571e-001, 2.908431e-003
15580, -1.649949e-001, 3.190413e-001, 2.908431e-003
15581, -1.654659e-001, 3.199254e-001, 2.908431e-003
15582, -1.659368e-001, 3.208095e-001, 2.908431e-003
15583, -1.664078e-001, 3.216937e-001, 2.908431e-003
15584, -1.668788e-001, 3.225778e-001, 2.908431e-003
15585, -1.673497e-001, 3.234620e-001, 2.908431e-003
15586, -1.678207e-001, 3.243461e-001, 2.908431e-003
15587, -1.682916e-001, 3.252303e-001, 2.908431e-003
15588, -1.687626e-001, 3.261144e-001, 2.908431e-003
15589, -1.692335e-001, 3.269985e-001, 2.908431e-003
15590, -1.697045e-001, 3.278827e-001, 2.908431e-003
15591, -1.701754e-001, 3.287668e-001, 2.908431e-003
15592, -1.706464e-001, 3.296510e-001, 2.908431e-003
15593, -1.711173e-001, 3.305351e-001, 2.908431e-003
15594, -1.715883e-001, 3.314192e-001, 2.908431e-003
15595, -1.720592e-001, 3.323034e-001, 2.908431e-003
15596, -1.725302e-001, 3.331875e-001, 2.908431e-003
15597, -1.730011e-001, 3.340717e-001, 2.908431e-003
15598, -1.734721e-001, 3.349558e-001, 2.908431e-003
15599, -1.739430e-001, 3.358400e-001, 2.908431e-003
15600, -1.744140e-001, 3.367241e-001, 2.908431e-003
15601, -1.748849e-001, 3.376082e-001, 2.908431e-003
15602, -1.753559e-001, 3.384924e-001, 2.908431e-003
15603, -1.758268e-001, 3.393765e-001, 2.908431e-003
15604, -1.762978e-001, 3.402607e-001, 2.908431e-003
15605, -1.767687e-001, 3.411448e-001, 2.908431e-003
15606, -1.772397e-001, 3.420289e-001, 2.908431e-003
15607, -1.777106e-001, 3.429131e-001, 2.908431e-003
15608, -1.781816e-001, 3.437972e-001, 2.908431e-003
15609, -1.786525e-001, 3.446814e-001, 2.908431e-003
15610, -1.791235e-001, 3.455655e-001, 2.908431e-003
15611, -1.795944e-001, 3.464497e-001, 2.908431e-003
15612, -1.800654e-001, 3.473338e-001, 2.908431e-003
15613, -1.805363e-001, 3.482179e-001, 2.908431e-003
15614, -1.810073e-001, 3.491021e-001, 2.908431e-003
15615, -1.814782e-001, 3.499862e-001, 2.908431e-003
15616, -1.819492e-001, 3.508704e-001, 2.908431e-003
15617, -1.824201e-001, 3.517545e-001, 2.908431e-003
15618, -1.828911e-001, 3.526386e-001, 2.908431e-003
15619, -1.833620e-001, 3.535228e-001, 2.908431e-003
15620, -1.838330e-001, 3.544069e-001, 2.908431e-003
15621, -1.843039e-001, 3.552911e-001, 2.908431e-003
15622, -1.847749e-001, 3.561752e-001, 2.908431e-003
15623, -1.852459e-001, 3.570594e-001, 2.908431e-003
15624, -1.857168e-001, 3.579435e-001, 2.908431e-003
15625, -1.861878e-001, 3.588276e-001, 2.908431e-003
15626, -1.866587e-001, 3.597118e-001, 2.908431e-003
15627, -1.871297e-001, 3.605959e-001, 2.908431e-003
15628, -1.876006e-001, 3.614801e-001, 2.908431e-003
15629, -1.880716e-001, 3.623642e-001, 2.908431e-003
15630, -1.885425e-001, 3.632483e-001, 2.908431e-003
15631, -1.890135e-001, 3.641325e-001, 2.908431e-003
15632, -1.894844e-001, 3.650166e-001, 2.908431e-003
15633, -1.899554e-001, 3.659008e-001, 2.908431e-003
15634, -1.904263e-001, 3.667849e-001, 2.908431e-003
15635, -1.908973e-001, 3.676690e-001, 2.908431e-003
15636, -1.913682e-001, 3.685532e-001, 2.908431e-003
15637, -1.918392e-001, 3.694373e-001, 2.908431e-003
15638, -1.923101e-001, 3.703215e-001, 2.908431e-003
15639, -1.927811e-001, 3.712056e-001, 2.908431e-003
15640, -1.932520e-001, 3.720898e-001, 2.908431e-003
15641, -1.937230e-001, 3.729739e-001, 2.908431e-003
15642, -1.941939e-001, 3.738580e-001, 2.908431e-003
15643, -1.946649e-001, 3.747422e-001, 2.908431e-003
15644, -1.951358e-001, 3.756263e-001, 2.908431e-003
15645, -1.956068e-001, 3.765105e-001, 2.908431e-003
15646, -1.960777e-001, 3.773946e-001, 2.908431e-003
15647, -1.965487e-001, 3.782787e-001, 2.908431e-003
15648, -1.970196e-001, 3.791629e-001, 2.908431e-003
15649, -1.974906e-001, 3.800470e-001, 2.908431e-003
15650, -1.979615e-001, 3.809312e-001, 2.908431e-003
15651, -1.984325e-001, 3.818153e-001, 2.908431e-003
15652, -1.989034e-001, 3.826995e-001, 2.908431e-003
15653, -1.993744e-001, 3.835836e-001, 2.908431e-003
15654, -1.998453e-001, 3.844677e-001, 2.908431e-003
15655, -2.003163e-001, 3.853519e-001, 2.908431e-003
15656, -2.007872e-001, 3.862360e-001, 2.908431e-003
15657, -2.012582e-001, 3.871202e-001, 2.908431e-003
15658, -2.017291e-001, 3.880043e-001, 2.908431e-003
15659, -2.022001e-001, 3.888884e-001, 2.908431e-003
15660, -2.026711e-001, 3.897726e-001, 2.908431e-003
15661, -2.031420e-001, 3.906567e-001, 2.908431e-003
15662, -2.036130e-001, 3.915409e-001, 2.908431e-003
15663, -2.040839e-001, 3.924250e-001, 2.908431e-003
15664, -2.045549e-001, 3.933092e-001, 2.908431e-003
15665, -2.050258e-001, 3.941933e-001, 2.908431e-003
15666, -2.054968e-001, 3.950774e-001, 2.908431e-003
15667, -2.059677e-001, 3.959616e-001, 2.908431e-003
15668, -2.064387e-001, 3.968457e-001, 2.908431e-003
15669, -2.069096e-001, 3.977299e-001, 2.908431e-003
15670, -2.073806e-001, 3.986140e-001, 2.908431e-003
15671, -2.078515e-001, 3.994981e-001, 2.908431e-003
15672, -2.083225e-001, 4.003823e-001, 2.908431e-003
15673, -2.087934e-001, 4.012664e-001, 2.908431e-003
15674, -2.092644e-001, 4.021506e-001, 2.908431e-003
15675, -2.097353e-001, 4.030347e-001, 2.908431e-003
15676, -2.102063e-001, 4.039188e-001, 2.908431e-003
15677, -2.106772e-001, 4.048030e-001, 2.908431e-003
15678, -2.111482e-001, 4.056871e-001, 2.908429e-003
15679, -2.116191e-001, 4.065713e-001, 2.908417e-003
15680, -2.120901e-001, 4.074555e-001, 2.908376e-003
15681, -2.125611e-001, 4.083398e-001, 2.908294e-003
15682, -2.130320e-001, 4.092240e-001, 2.908186e-003
15683, -2.135029e-001, 4.101082e-001, 2.908082e-003
15684, -2.139256e-001, 4.098834e-001, 3.784674e-003
15685, -2.150775e-001, 4.092707e-001, 5.290359e-003
15686, -2.144540e-001, 4.096023e-001, 4.584188e-003
15687, -2.157833e-001, 4.088951e-001, 5.888846e-003
15688, -2.165571e-001, 4.084833e-001, 6.367463e-003
15689, -2.173831e-001, 4.080436e-001, 6.716470e-003
15690, -2.182445e-001, 4.075849e-001, 6.928756e-003
15691, -2.191238e-001, 4.071167e-001, 7.000000e-003
15692, -2.200031e-001, 4.066484e-001, 6.928750e-003
15693, -2.208644e-001, 4.061896e-001, 6.716453e-003
15694, -2.216903e-001, 4.057496e-001, 6.367431e-003
15695, -2.224639e-001, 4.053375e-001, 5.888788e-003
15696, -2.231696e-001, 4.049616e-001, 5.290269e-003
15697, -2.237930e-001, 4.046298e-001, 4.584063e-003
15698, -2.243216e-001, 4.043491e-001, 3.784547e-003
15699, -2.247447e-001, 4.041251e-001, 2.907974e-003
15700, -2.242749e-001, 4.032432e-001, 2.908032e-003
15701, -2.233357e-001, 4.014802e-001, 2.908209e-003
15702, -2.238052e-001, 4.023616e-001, 2.908108e-003
15703, -2.228663e-001, 4.005991e-001, 2.908307e-003
15704, -2.223969e-001, 3.997179e-001, 2.908382e-003
15705, -2.219274e-001, 3.988366e-001, 2.908422e-003
15706, -2.214580e-001, 3.979553e-001, 2.908440e-003
15707, -2.209885e-001, 3.970739e-001, 2.908447e-003
15708, -2.205190e-001, 3.961926e-001, 2.908449e-003
15709, -2.200495e-001, 3.953112e-001, 2.908450e-003
15710, -2.195801e-001, 3.944298e-001, 2.908450e-003
15711, -2.191106e-001, 3.935484e-001, 2.908450e-003
15712, -2.186411e-001, 3.926670e-001, 2.908450e-003
15713, -2.181716e-001, 3.917856e-001, 2.908450e-003
15714, -2.177021e-001, 3.909043e-001, 2.908450e-003
15715, -2.172326e-001, 3.900229e-001, 2.908450e-003
15716, -2.167632e-001, 3.891415e-001, 2.908450e-003
15717, -2.162937e-001, 3.882601e-001, 2.908450e-003
15718, -2.158242e-001, 3.873787e-001, 2.908450e-003
15719, -2.153547e-001, 3.864973e-001, 2.908450e-003
15720, -2.148852e-001, 3.856160e-001, 2.908450e-003
15721, -2.144157e-001, 3.847346e-001, 2.908450e-003
15722, -2.139463e-001, 3.838532e-001, 2.908450e-003
15723, -2.134768e-001, 3.829718e-001, 2.908450e-003
15724, -2.130073e-001, 3.820904e-001, 2.908450e-003
15725, -2.125378e-001, 3.812090e-001, 2.908450e-003
15726, -2.120683e-001, 3.803277e-001, 2.908450e-003
15727, -2.115989e-001, 3.794463e-001, 2.908450e-003
15728, -2.111294e-001, 3.785649e-001, 2.908450e-003
15729, -2.106599e-001, 3.776835e-001, 2.908450e-003
15730, -2.101904e-001, 3.768021e-001, 2.908450e-003
15731, -2.097209e-001, 3.759207e-001, 2.908450e-003
15732, -2.092514e-001, 3.750394e-001, 2.908450e-003
15733, -2.087820e-001, 3.741580e-001, 2.908450e-003
15734, -2.083125e-001, 3.732766e-001, 2.908450e-003
15735, -2.078430e-001, 3.723952e-001, 2.908450e-003
15736, -2.073735e-001, 3.715138e-001, 2.908450e-003
15737, -2.069040e-001, 3.706324e-001, 2.908450e-003
15738, -2.064345e-001, 3.697511e-001, 2.908450e-003
15739, -2.059651e-001, 3.688697e-001, 2.908450e-003
15740, -2.054956e-001, 3.679883e-001, 2.908450e-003
15741, -2.050261e-001, 3.671069e-001, 2.908450e-003
15742, -2.045566e-001, 3.662255e-001, 2.908450e-003
15743, -2.040871e-001, 3.653441e-001, 2.908450e-003
15744, -2.036177e-001, 3.644627e-001, 2.908450e-003
15745, -2.031482e-001, 3.635814e-001, 2.908450e-003
15746, -2.026787e-001, 3.627000e-001, 2.908450e-003
15747, -2.022092e-001, 3.618186e-001, 2.908450e-003
15748, -2.017397e-001, 3.609372e-001, 2.908450e-003
15749, -2.012702e-001, 3.600558e-001, 2.908450e-003
15750, -2.008008e-001, 3.591744e-001, 2.908450e-003
15751, -2.003313e-001, 3.582931e-001, 2.908450e-003
15752, -1.998618e-001, 3.574117e-001, 2.908450e-003
15753, -1.993923e-001, 3.565303e-001, 2.908450e-003
15754, -1.989228e-001, 3.556489e-001, 2.908450e-003
15755, -1.984533e-001, 3.547675e-001, 2.908450e-003
15756, -1.979839e-001, 3.538861e-001, 2.908450e-003
15757, -1.975144e-001, 3.530048e-001, 2.908450e-003
15758, -1.970449e-001, 3.521234e-001, 2.908450e-003
15759, -1.965754e-001, 3.512420e-001, 2.908450e-003
15760, -1.961059e-001, 3.503606e-001, 2.908450e-003
15761, -1.956365e-001, 3.494792e-001, 2.908450e-003
15762, -1.951670e-001, 3.485978e-001, 2.908450e-003
15763, -1.946975e-001, 3.477165e-001, 2.908450e-003
15764, -1.942280e-001, 3.468351e-001, 2.908450e-003
15765, -1.937585e-001, 3.459537e-001, 2.908450e-003
15766, -1.932890e-001, 3.450723e-001, 2.908450e-003
15767, -1.928196e-001, 3.441909e-001, 2.908450e-003
15768, -1.923501e-001, 3.433095e-001, 2.908450e-003
15769, -1.918806e-001, 3.424282e-001, 2.908450e-003
15770, -1.914111e-001, 3.415468e-001, 2.908450e-003
15771, -1.909416e-001, 3.406654e-001, 2.908450e-003
15772, -1.904721e-001, 3.397840e-001, 2.908450e-003
15773, -1.900027e-001, 3.389026e-001, 2.908450e-003
15774, -1.895332e-001, 3.380212e-001, 2.908450e-003
15775, -1.890637e-001, 3.371398e-001, 2.908450e-003
15776, -1.885942e-001, 3.362585e-001, 2.908450e-003
15777, -1.881247e-001, 3.353771e-001, 2.908450e-003
15778, -1.876553e-001, 3.344957e-001, 2.908450e-003
15779, -1.871858e-001, 3.336143e-001, 2.908450e-003
15780, -1.867163e-001, 3.327329e-001, 2.908450e-003
15781, -1.862468e-001, 3.318515e-001, 2.908450e-003
15782, -1.857773e-001, 3.309702e-001, 2.908450e-003
15783, -1.853078e-001, 3.300888e-001, 2.908450e-003
15784, -1.848384e-001, 3.292074e-001, 2.908450e-003
15785, -1.843689e-001, 3.283260e-001, 2.908450e-003
15786, -1.838994e-001, 3.274446e-001, 2.908450e-003
15787, -1.834299e-001, 3.265632e-001, 2.908450e-003
15788, -1.829604e-001, 3.256819e-001, 2.908450e-003
15789, -1.824909e-001, 3.248005e-001, 2.908450e-003
15790, -1.820215e-001, 3.239191e-001, 2.908450e-003
15791, -1.815520e-001, 3.230377e-001, 2.908450e-003
15792, -1.810825e-001, 3.221563e-001, 2.908450e-003
15793, -1.806130e-001, 3.212749e-001, 2.908450e-003
15794, -1.801435e-001, 3.203936e-001, 2.908450e-003
15795, -1.796741e-001, 3.195122e-001, 2.908450e-003
15796, -1.792046e-001, 3.186308e-001, 2.908450e-003
15797, -1.787351e-001, 3.177494e-001, 2.908450e-003
15798, -1.782656e-001, 3.168680e-001, 2.908450e-003
15799, -1.777961e-001, 3.159866e-001, 2.908450e-003
15800, -1.773266e-001, 3.151053e-001, 2.908450e-003
15801, -1.768572e-001, 3.142239e-001, 2.908450e-003
15802, -1.763877e-001, 3.133425e-001, 2.908450e-003
15803, -1.759182e-001, 3.124611e-001, 2.908450e-003
15804, -1.754487e-001, 3.115797e-001, 2.908450e-003
15805, -1.749792e-001, 3.106983e-001, 2.908450e-003
15806, -1.745097e-001, 3.098169e-001, 2.908450e-003
15807, -1.740403e-001, 3.089356e-001, 2.908450e-003
15808, -1.735708e-001, 3.080542e-001, 2.908450e-003
15809, -1.731013e-001, 3.071728e-001, 2.908450e-003
15810, -1.726318e-001, 3.062914e-001, 2.908450e-003
15811, -1.721623e-001, 3.054100e-001, 2.908450e-003
15812, -1.716928e-001, 3.045286e-001, 2.908450e-003
15813, -1.712234e-001, 3.036473e-001, 2.908450e-003
15814, -1.707539e-001, 3.027659e-001, 2.908450e-003
15815, -1.702844e-001, 3.018845e-001, 2.908450e-003
15816, -1.698149e-001, 3.010031e-001, 2.908450e-003
15817, -1.693454e-001, 3.001217e-001, 2.908450e-003
15818, -1.688760e-001, 2.992403e-001, 2.908450e-003
15819, -1.684065e-001, 2.983590e-001, 2.908450e-003
15820, -1.679370e-001, 2.974776e-001, 2.908450e-003
15821, -1.674675e-001, 2.965962e-001, 2.908450e-003
15822, -1.669980e-001, 2.957148e-001, 2.908450e-003
15823, -1.665285e-001, 2.948334e-001, 2.908450e-003
15824, -1.660591e-001, 2.939520e-001, 2.908450e-003
15825, -1.655896e-001, 2.930707e-001, 2.908450e-003
15826, -1.651201e-001, 2.921893e-001, 2.908450e-003
15827, -1.646506e-001, 2.913079e-001, 2.908450e-003
15828, -1.641811e-001, 2.904265e-001, 2.908450e-003
15829, -1.637116e-001, 2.895451e-001, 2.908450e-003
15830, -1.632422e-001, 2.886637e-001, 2.908450e-003
15831, -1.627727e-001, 2.877824e-001, 2.908450e-003
15832, -1.623032e-001, 2.869010e-001, 2.908450e-003
15833, -1.618337e-001, 2.860196e-001, 2.908450e-003
15834, -1.613642e-001, 2.851382e-001, 2.908450e-003
15835, -1.608948e-001, 2.842568e-001, 2.908450e-003
15836, -1.604253e-001, 2.833754e-001, 2.908450e-003
15837, -1.599558e-001, 2.824940e-001, 2.908450e-003
15838, -1.594863e-001, 2.816127e-001, 2.908450e-003
15839, -1.590168e-001, 2.807313e-001, 2.908450e-003
15840, -1.585473e-001, 2.798499e-001, 2.908450e-003
15841, -1.580779e-001, 2.789685e-001, 2.908450e-003
15842, -1.576084e-001, 2.780871e-001, 2.908450e-003
15843, -1.571389e-001, 2.772057e-001, 2.908450e-003
15844, -1.566694e-001, 2.763244e-001, 2.908450e-003
15845, -1.561999e-001, 2.754430e-001, 2.908450e-003
15846, -1.557304e-001, 2.745616e-001, 2.908450e-003
15847, -1.552610e-001, 2.736802e-001, 2.908450e-003
15848, -1.547915e-001, 2.727988e-001, 2.908450e-003
15849, -1.543220e-001, 2.719174e-001, 2.908450e-003
15850, -1.538525e-001, 2.710361e-001, 2.908450e-003
15851, -1.533830e-001, 2.701547e-001, 2.908450e-003
15852, -1.529136e-001, 2.692733e-001, 2.908450e-003
15853, -1.524441e-001, 2.683919e-001, 2.908450e-003
15854, -1.519746e-001, 2.675105e-001, 2.908450e-003
15855, -1.515051e-001, 2.666291e-001, 2.908450e-003
15856, -1.510356e-001, 2.657478e-001, 2.908450e-003
15857, -1.505661e-001, 2.648664e-001, 2.908450e-003
15858, -1.500967e-001, 2.639850e-001, 2.908450e-003
15859, -1.496272e-001, 2.631036e-001, 2.908448e-003
15860, -1.491576e-001, 2.622222e-001, 2.908521e-003
15861, -1.486874e-001, 2.613406e-001, 2.909819e-003
15862, -1.482147e-001, 2.604608e-001, 2.917568e-003
15863, -1.477382e-001, 2.595916e-001, 2.943525e-003
15864, -1.472679e-001, 2.587607e-001, 2.995726e-003
15865, -1.468417e-001, 2.580113e-001, 3.045500e-003
15866, -1.464870e-001, 2.571476e-001, 2.845129e-003
15867, -1.463227e-001, 2.565471e-001, 2.513929e-003
15868, -1.461642e-001, 2.559683e-001, 2.138695e-003
15869, -1.349580e-001, 2.421390e-001, 6.185964e-003
15870, -1.354124e-001, 2.436052e-001, 6.330234e-003
15871, -1.358900e-001, 2.449116e-001, 6.417639e-003
15872, -1.364523e-001, 2.461341e-001, 6.451239e-003
15873, -1.370550e-001, 2.472740e-001, 6.452887e-003
15874, -1.376880e-001, 2.483538e-001, 6.431199e-003
15875, -1.383593e-001, 2.493853e-001, 6.383911e-003
15876, -1.390608e-001, 2.503659e-001, 6.310409e-003
15877, -1.397849e-001, 2.513053e-001, 6.211729e-003
15878, -1.405351e-001, 2.522149e-001, 6.084162e-003
15879, -1.413191e-001, 2.531023e-001, 5.919380e-003
15880, -1.421457e-001, 2.539717e-001, 5.704314e-003
15881, -1.430255e-001, 2.548244e-001, 5.417505e-003
15882, -1.439648e-001, 2.556482e-001, 5.023807e-003
15883, -1.449568e-001, 2.564059e-001, 4.461565e-003
15884, -1.458792e-001, 2.569236e-001, 3.663729e-003
15885, -1.267992e-001, 2.463167e-001, 3.784610e-003
15886, -1.286834e-001, 2.498531e-001, 3.785177e-003
15887, -1.282123e-001, 2.489690e-001, 3.785032e-003
15888, -1.273275e-001, 2.460353e-001, 4.584114e-003
15889, -1.279508e-001, 2.457031e-001, 5.290351e-003
15890, -1.286571e-001, 2.453275e-001, 5.889136e-003
15891, -1.294332e-001, 2.449185e-001, 6.368011e-003
15892, -1.302613e-001, 2.444875e-001, 6.716167e-003
15893, -1.311230e-001, 2.440473e-001, 6.927382e-003
15894, -1.320105e-001, 2.436135e-001, 6.999976e-003
15895, -1.329392e-001, 2.432144e-001, 6.929800e-003
15896, -1.339093e-001, 2.427508e-001, 6.689084e-003
15897, -1.277413e-001, 2.480848e-001, 3.784856e-003
15898, -1.272702e-001, 2.472008e-001, 3.784705e-003
15899, -1.296252e-001, 2.516212e-001, 3.785225e-003
15900, -1.291543e-001, 2.507370e-001, 3.785385e-003
15901, -1.300960e-001, 2.525051e-001, 3.785117e-003
15902, -1.305671e-001, 2.533892e-001, 3.785382e-003
15903, -1.310383e-001, 2.542736e-001, 3.785556e-003
15904, -1.315094e-001, 2.551581e-001, 3.785490e-003
15905, -1.319806e-001, 2.560425e-001, 3.785612e-003
15906, -1.324518e-001, 2.569270e-001, 3.785798e-003
15907, -1.329227e-001, 2.578113e-001, 3.785588e-003
15908, -1.333932e-001, 2.586952e-001, 3.785069e-003
15909, -1.338639e-001, 2.595792e-001, 3.784883e-003
15910, -1.343348e-001, 2.604630e-001, 3.785008e-003
15911, -1.348058e-001, 2.613470e-001, 3.785139e-003
15912, -1.352767e-001, 2.622311e-001, 3.785200e-003
15913, -1.357477e-001, 2.631152e-001, 3.785220e-003
15914, -1.362186e-001, 2.639994e-001, 3.785226e-003
15915, -1.366896e-001, 2.648835e-001, 3.785227e-003
15916, -1.371605e-001, 2.657676e-001, 3.785228e-003
15917, -1.376315e-001, 2.666518e-001, 3.785228e-003
15918, -1.381024e-001, 2.675359e-001, 3.785228e-003
15919, -1.385734e-001, 2.684201e-001, 3.785228e-003
15920, -1.390443e-001, 2.693042e-001, 3.785228e-003
15921, -1.395153e-001, 2.701883e-001, 3.785228e-003
15922, -1.399862e-001, 2.710725e-001, 3.785228e-003
15923, -1.404572e-001, 2.719566e-001, 3.785228e-003
15924, -1.409281e-001, 2.728408e-001, 3.785228e-003
15925, -1.413991e-001, 2.737249e-001, 3.785228e-003
15926, -1.418700e-001, 2.746091e-001, 3.785228e-003
15927, -1.423410e-001, 2.754932e-001, 3.785228e-003
15928, -1.428119e-001, 2.763773e-001, 3.785228e-003
15929, -1.432829e-001, 2.772615e-001, 3.785228e-003
15930, -1.437538e-001, 2.781456e-001, 3.785228e-003
15931, -1.442248e-001, 2.790298e-001, 3.785228e-003
15932, -1.446958e-001, 2.799139e-001, 3.785228e-003
15933, -1.451667e-001, 2.807980e-001, 3.785228e-003
15934, -1.456377e-001, 2.816822e-001, 3.785228e-003
15935, -1.461086e-001, 2.825663e-001, 3.785228e-003
15936, -1.465796e-001, 2.834505e-001, 3.785228e-003
15937, -1.470505e-001, 2.843346e-001, 3.785228e-003
15938, -1.475215e-001, 2.852188e-001, 3.785228e-003
15939, -1.479924e-001, 2.861029e-001, 3.785228e-003
15940, -1.484634e-001, 2.869870e-001, 3.785228e-003
15941, -1.489343e-001, 2.878712e-001, 3.785228e-003
15942, -1.494053e-001, 2.887553e-001, 3.785228e-003
15943, -1.498762e-001, 2.896395e-001, 3.785228e-003
15944, -1.503472e-001, 2.905236e-001, 3.785228e-003
15945, -1.508181e-001, 2.914077e-001, 3.785228e-003
15946, -1.512891e-001, 2.922919e-001, 3.785228e-003
15947, -1.517600e-001, 2.931760e-001, 3.785228e-003
15948, -1.522310e-001, 2.940602e-001, 3.785228e-003
15949, -1.527019e-001, 2.949443e-001, 3.785228e-003
15950, -1.531729e-001, 2.958284e-001, 3.785228e-003
15951, -1.536438e-001, 2.967126e-001, 3.785228e-003
15952, -1.541148e-001, 2.975967e-001, 3.785228e-003
15953, -1.545857e-001, 2.984809e-001, 3.785228e-003
15954, -1.550567e-001, 2.993650e-001, 3.785228e-003
15955, -1.555276e-001, 3.002492e-001, 3.785228e-003
15956, -1.559986e-001, 3.011333e-001, 3.785228e-003
15957, -1.564695e-001, 3.020174e-001, 3.785228e-003
15958, -1.569405e-001, 3.029016e-001, 3.785228e-003
15959, -1.574114e-001, 3.037857e-001, 3.785228e-003
15960, -1.578824e-001, 3.046699e-001, 3.785228e-003
15961, -1.583533e-001, 3.055540e-001, 3.785228e-003
15962, -1.588243e-001, 3.064381e-001, 3.785228e-003
15963, -1.592952e-001, 3.073223e-001, 3.785228e-003
15964, -1.597662e-001, 3.082064e-001, 3.785228e-003
15965, -1.602371e-001, 3.090906e-001, 3.785228e-003
15966, -1.607081e-001, 3.099747e-001, 3.785228e-003
15967, -1.611790e-001, 3.108589e-001, 3.785228e-003
15968, -1.616500e-001, 3.117430e-001, 3.785228e-003
15969, -1.621210e-001, 3.126271e-001, 3.785228e-003
15970, -1.625919e-001, 3.135113e-001, 3.785228e-003
15971, -1.630629e-001, 3.143954e-001, 3.785228e-003
15972, -1.635338e-001, 3.152796e-001, 3.785228e-003
15973, -1.640048e-001, 3.161637e-001, 3.785228e-003
15974, -1.644757e-001, 3.170478e-001, 3.785228e-003
15975, -1.649467e-001, 3.179320e-001, 3.785228e-003
15976, -1.654176e-001, 3.188161e-001, 3.785228e-003
15977, -1.658886e-001, 3.197003e-001, 3.785228e-003
15978, -1.663595e-001, 3.205844e-001, 3.785228e-003
15979, -1.668305e-001, 3.214686e-001, 3.785228e-003
15980, -1.673014e-001, 3.223527e-001, 3.785228e-003
15981, -1.677724e-001, 3.232368e-001, 3.785228e-003
15982, -1.682433e-001, 3.241210e-001, 3.785228e-003
15983, -1.687143e-001, 3.250051e-001, 3.785228e-003
15984, -1.691852e-001, 3.258893e-001, 3.785228e-003
15985, -1.696562e-001, 3.267734e-001, 3.785228e-003
15986, -1.701271e-001, 3.276575e-001, 3.785228e-003
15987, -1.705981e-001, 3.285417e-001, 3.785228e-003
15988, -1.710690e-001, 3.294258e-001, 3.785228e-003
15989, -1.715400e-001, 3.303100e-001, 3.785228e-003
15990, -1.720109e-001, 3.311941e-001, 3.785228e-003
15991, -1.724819e-001, 3.320783e-001, 3.785228e-003
15992, -1.729528e-001, 3.329624e-001, 3.785228e-003
15993, -1.734238e-001, 3.338465e-001, 3.785228e-003
15994, -1.738947e-001, 3.347307e-001, 3.785228e-003
15995, -1.743657e-001, 3.356148e-001, 3.785228e-003
15996, -1.748366e-001, 3.364990e-001, 3.785228e-003
15997, -1.753076e-001, 3.373831e-001, 3.785228e-003
15998, -1.757785e-001, 3.382672e-001, 3.785228e-003
15999, -1.762495e-001, 3.391514e-001, 3.785228e-003
16000, -1.767204e-001, 3.400355e-001, 3.785228e-003
16001, -1.771914e-001, 3.409197e-001, 3.785228e-003
16002, -1.776623e-001, 3.418038e-001, 3.785228e-003
16003, -1.781333e-001, 3.426879e-001, 3.785228e-003
16004, -1.786042e-001, 3.435721e-001, 3.785228e-003
16005, -1.790752e-001, 3.444562e-001, 3.785228e-003
16006, -1.795461e-001, 3.453404e-001, 3.785228e-003
16007, -1.800171e-001, 3.462245e-001, 3.785228e-003
16008, -1.804881e-001, 3.471087e-001, 3.785228e-003
16009, -1.809590e-001, 3.479928e-001, 3.785228e-003
16010, -1.814300e-001, 3.488769e-001, 3.785228e-003
16011, -1.819009e-001, 3.497611e-001, 3.785228e-003
16012, -1.823719e-001, 3.506452e-001, 3.785228e-003
16013, -1.828428e-001, 3.515294e-001, 3.785228e-003
16014, -1.833138e-001, 3.524135e-001, 3.785228e-003
16015, -1.837847e-001, 3.532976e-001, 3.785228e-003
16016, -1.842557e-001, 3.541818e-001, 3.785228e-003
16017, -1.847266e-001, 3.550659e-001, 3.785228e-003
16018, -1.851976e-001, 3.559501e-001, 3.785228e-003
16019, -1.856685e-001, 3.568342e-001, 3.785228e-003
16020, -1.861395e-001, 3.577184e-001, 3.785228e-003
16021, -1.866104e-001, 3.586025e-001, 3.785228e-003
16022, -1.870814e-001, 3.594866e-001, 3.785228e-003
16023, -1.875523e-001, 3.603708e-001, 3.785228e-003
16024, -1.880233e-001, 3.612549e-001, 3.785228e-003
16025, -1.884942e-001, 3.621391e-001, 3.785228e-003
16026, -1.889652e-001, 3.630232e-001, 3.785228e-003
16027, -1.894361e-001, 3.639073e-001, 3.785228e-003
16028, -1.899071e-001, 3.647915e-001, 3.785228e-003
16029, -1.903780e-001, 3.656756e-001, 3.785228e-003
16030, -1.908490e-001, 3.665598e-001, 3.785228e-003
16031, -1.913199e-001, 3.674439e-001, 3.785228e-003
16032, -1.917909e-001, 3.683281e-001, 3.785228e-003
16033, -1.922618e-001, 3.692122e-001, 3.785228e-003
16034, -1.927328e-001, 3.700963e-001, 3.785228e-003
16035, -1.932037e-001, 3.709805e-001, 3.785228e-003
16036, -1.936747e-001, 3.718646e-001, 3.785228e-003
16037, -1.941456e-001, 3.727488e-001, 3.785228e-003
16038, -1.946166e-001, 3.736329e-001, 3.785228e-003
16039, -1.950875e-001, 3.745170e-001, 3.785228e-003
16040, -1.955585e-001, 3.754012e-001, 3.785228e-003
16041, -1.960294e-001, 3.762853e-001, 3.785228e-003
16042, -1.965004e-001, 3.771695e-001, 3.785228e-003
16043, -1.969713e-001, 3.780536e-001, 3.785228e-003
16044, -1.974423e-001, 3.789377e-001, 3.785228e-003
16045, -1.979133e-001, 3.798219e-001, 3.785228e-003
16046, -1.983842e-001, 3.807060e-001, 3.785228e-003
16047, -1.988552e-001, 3.815902e-001, 3.785228e-003
16048, -1.993261e-001, 3.824743e-001, 3.785228e-003
16049, -1.997971e-001, 3.833585e-001, 3.785228e-003
16050, -2.002680e-001, 3.842426e-001, 3.785228e-003
16051, -2.007390e-001, 3.851267e-001, 3.785228e-003
16052, -2.012099e-001, 3.860109e-001, 3.785228e-003
16053, -2.016809e-001, 3.868950e-001, 3.785228e-003
16054, -2.021518e-001, 3.877792e-001, 3.785228e-003
16055, -2.026228e-001, 3.886633e-001, 3.785228e-003
16056, -2.030937e-001, 3.895474e-001, 3.785228e-003
16057, -2.035647e-001, 3.904316e-001, 3.785228e-003
16058, -2.040356e-001, 3.913157e-001, 3.785228e-003
16059, -2.045066e-001, 3.921999e-001, 3.785228e-003
16060, -2.049775e-001, 3.930840e-001, 3.785228e-003
16061, -2.054485e-001, 3.939682e-001, 3.785228e-003
16062, -2.059194e-001, 3.948523e-001, 3.785228e-003
16063, -2.063904e-001, 3.957364e-001, 3.785228e-003
16064, -2.068613e-001, 3.966206e-001, 3.785228e-003
16065, -2.073323e-001, 3.975047e-001, 3.785228e-003
16066, -2.078032e-001, 3.983889e-001, 3.785228e-003
16067, -2.082742e-001, 3.992730e-001, 3.785228e-003
16068, -2.087451e-001, 4.001571e-001, 3.785228e-003
16069, -2.092161e-001, 4.010413e-001, 3.785228e-003
16070, -2.096870e-001, 4.019254e-001, 3.785228e-003
16071, -2.101580e-001, 4.028096e-001, 3.785228e-003
16072, -2.106289e-001, 4.036937e-001, 3.785228e-003
16073, -2.110999e-001, 4.045779e-001, 3.785227e-003
16074, -2.115708e-001, 4.054620e-001, 3.785218e-003
16075, -2.120418e-001, 4.063463e-001, 3.785184e-003
16076, -2.125128e-001, 4.072306e-001, 3.785101e-003
16077, -2.129838e-001, 4.081149e-001, 3.784968e-003
16078, -2.134547e-001, 4.089992e-001, 3.784811e-003
16079, -2.160866e-001, 4.075997e-001, 6.367534e-003
16080, -2.153127e-001, 4.080113e-001, 5.888958e-003
16081, -2.169127e-001, 4.071601e-001, 6.716511e-003
16082, -2.146068e-001, 4.083867e-001, 5.290507e-003
16083, -2.139832e-001, 4.087182e-001, 4.584347e-003
16084, -2.177742e-001, 4.067017e-001, 6.928770e-003
16085, -2.186535e-001, 4.062336e-001, 7.000000e-003
16086, -2.195328e-001, 4.057654e-001, 6.928747e-003
16087, -2.203941e-001, 4.053067e-001, 6.716456e-003
16088, -2.212200e-001, 4.048669e-001, 6.367446e-003
16089, -2.219937e-001, 4.044548e-001, 5.888816e-003
16090, -2.226995e-001, 4.040791e-001, 5.290311e-003
16091, -2.233230e-001, 4.037475e-001, 4.584118e-003
16092, -2.238518e-001, 4.034671e-001, 3.784610e-003
16093, -2.219738e-001, 3.999421e-001, 3.785129e-003
16094, -2.224431e-001, 4.008231e-001, 3.784995e-003
16095, -2.215044e-001, 3.990610e-001, 3.785199e-003
16096, -2.229125e-001, 4.017041e-001, 3.784837e-003
16097, -2.233821e-001, 4.025854e-001, 3.784702e-003
16098, -2.210349e-001, 3.981797e-001, 3.785232e-003
16099, -2.205655e-001, 3.972984e-001, 3.785243e-003
16100, -2.200960e-001, 3.964170e-001, 3.785247e-003
16101, -2.196265e-001, 3.955356e-001, 3.785248e-003
16102, -2.191570e-001, 3.946543e-001, 3.785248e-003
16103, -2.186875e-001, 3.937729e-001, 3.785248e-003
16104, -2.182181e-001, 3.928915e-001, 3.785248e-003
16105, -2.177486e-001, 3.920101e-001, 3.785248e-003
16106, -2.172791e-001, 3.911287e-001, 3.785248e-003
16107, -2.168096e-001, 3.902473e-001, 3.785248e-003
16108, -2.163401e-001, 3.893660e-001, 3.785248e-003
16109, -2.158707e-001, 3.884846e-001, 3.785248e-003
16110, -2.154012e-001, 3.876032e-001, 3.785248e-003
16111, -2.149317e-001, 3.867218e-001, 3.785248e-003
16112, -2.144622e-001, 3.858404e-001, 3.785248e-003
16113, -2.139927e-001, 3.849590e-001, 3.785248e-003
16114, -2.135232e-001, 3.840777e-001, 3.785248e-003
16115, -2.130538e-001, 3.831963e-001, 3.785248e-003
16116, -2.125843e-001, 3.823149e-001, 3.785248e-003
16117, -2.121148e-001, 3.814335e-001, 3.785248e-003
16118, -2.116453e-001, 3.805521e-001, 3.785248e-003
16119, -2.111758e-001, 3.796707e-001, 3.785248e-003
16120, -2.107063e-001, 3.787894e-001, 3.785248e-003
16121, -2.102369e-001, 3.779080e-001, 3.785248e-003
16122, -2.097674e-001, 3.770266e-001, 3.785248e-003
16123, -2.092979e-001, 3.761452e-001, 3.785248e-003
16124, -2.088284e-001, 3.752638e-001, 3.785248e-003
16125, -2.083589e-001, 3.743824e-001, 3.785248e-003
16126, -2.078895e-001, 3.735011e-001, 3.785248e-003
16127, -2.074200e-001, 3.726197e-001, 3.785248e-003
16128, -2.069505e-001, 3.717383e-001, 3.785248e-003
16129, -2.064810e-001, 3.708569e-001, 3.785248e-003
16130, -2.060115e-001, 3.699755e-001, 3.785248e-003
16131, -2.055420e-001, 3.690941e-001, 3.785248e-003
16132, -2.050726e-001, 3.682127e-001, 3.785248e-003
16133, -2.046031e-001, 3.673314e-001, 3.785248e-003
16134, -2.041336e-001, 3.664500e-001, 3.785248e-003
16135, -2.036641e-001, 3.655686e-001, 3.785248e-003
16136, -2.031946e-001, 3.646872e-001, 3.785248e-003
16137, -2.027251e-001, 3.638058e-001, 3.785248e-003
16138, -2.022557e-001, 3.629244e-001, 3.785248e-003
16139, -2.017862e-001, 3.620431e-001, 3.785248e-003
16140, -2.013167e-001, 3.611617e-001, 3.785248e-003
16141, -2.008472e-001, 3.602803e-001, 3.785248e-003
16142, -2.003777e-001, 3.593989e-001, 3.785248e-003
16143, -1.999082e-001, 3.585175e-001, 3.785248e-003
16144, -1.994388e-001, 3.576361e-001, 3.785248e-003
16145, -1.989693e-001, 3.567548e-001, 3.785248e-003
16146, -1.984998e-001, 3.558734e-001, 3.785248e-003
16147, -1.980303e-001, 3.549920e-001, 3.785248e-003
16148, -1.975608e-001, 3.541106e-001, 3.785248e-003
16149, -1.970914e-001, 3.532292e-001, 3.785248e-003
16150, -1.966219e-001, 3.523478e-001, 3.785248e-003
16151, -1.961524e-001, 3.514665e-001, 3.785248e-003
16152, -1.956829e-001, 3.505851e-001, 3.785248e-003
16153, -1.952134e-001, 3.497037e-001, 3.785248e-003
16154, -1.947439e-001, 3.488223e-001, 3.785248e-003
16155, -1.942745e-001, 3.479409e-001, 3.785248e-003
16156, -1.938050e-001, 3.470595e-001, 3.785248e-003
16157, -1.933355e-001, 3.461782e-001, 3.785248e-003
16158, -1.928660e-001, 3.452968e-001, 3.785248e-003
16159, -1.923965e-001, 3.444154e-001, 3.785248e-003
16160, -1.919270e-001, 3.435340e-001, 3.785248e-003
16161, -1.914576e-001, 3.426526e-001, 3.785248e-003
16162, -1.909881e-001, 3.417712e-001, 3.785248e-003
16163, -1.905186e-001, 3.408898e-001, 3.785248e-003
16164, -1.900491e-001, 3.400085e-001, 3.785248e-003
16165, -1.895796e-001, 3.391271e-001, 3.785248e-003
16166, -1.891102e-001, 3.382457e-001, 3.785248e-003
16167, -1.886407e-001, 3.373643e-001, 3.785248e-003
16168, -1.881712e-001, 3.364829e-001, 3.785248e-003
16169, -1.877017e-001, 3.356015e-001, 3.785248e-003
16170, -1.872322e-001, 3.347202e-001, 3.785248e-003
16171, -1.867627e-001, 3.338388e-001, 3.785248e-003
16172, -1.862933e-001, 3.329574e-001, 3.785248e-003
16173, -1.858238e-001, 3.320760e-001, 3.785248e-003
16174, -1.853543e-001, 3.311946e-001, 3.785248e-003
16175, -1.848848e-001, 3.303132e-001, 3.785248e-003
16176, -1.844153e-001, 3.294319e-001, 3.785248e-003
16177, -1.839458e-001, 3.285505e-001, 3.785248e-003
16178, -1.834764e-001, 3.276691e-001, 3.785248e-003
16179, -1.830069e-001, 3.267877e-001, 3.785248e-003
16180, -1.825374e-001, 3.259063e-001, 3.785248e-003
16181, -1.820679e-001, 3.250249e-001, 3.785248e-003
16182, -1.815984e-001, 3.241436e-001, 3.785248e-003
16183, -1.811290e-001, 3.232622e-001, 3.785248e-003
16184, -1.806595e-001, 3.223808e-001, 3.785248e-003
16185, -1.801900e-001, 3.214994e-001, 3.785248e-003
16186, -1.797205e-001, 3.206180e-001, 3.785248e-003
16187, -1.792510e-001, 3.197366e-001, 3.785248e-003
16188, -1.787815e-001, 3.188553e-001, 3.785248e-003
16189, -1.783121e-001, 3.179739e-001, 3.785248e-003
16190, -1.778426e-001, 3.170925e-001, 3.785248e-003
16191, -1.773731e-001, 3.162111e-001, 3.785248e-003
16192, -1.769036e-001, 3.153297e-001, 3.785248e-003
16193, -1.764341e-001, 3.144483e-001, 3.785248e-003
16194, -1.759646e-001, 3.135669e-001, 3.785248e-003
16195, -1.754952e-001, 3.126856e-001, 3.785248e-003
16196, -1.750257e-001, 3.118042e-001, 3.785248e-003
16197, -1.745562e-001, 3.109228e-001, 3.785248e-003
16198, -1.740867e-001, 3.100414e-001, 3.785248e-003
16199, -1.736172e-001, 3.091600e-001, 3.785248e-003
16200, -1.731478e-001, 3.082786e-001, 3.785248e-003
16201, -1.726783e-001, 3.073973e-001, 3.785248e-003
16202, -1.722088e-001, 3.065159e-001, 3.785248e-003
16203, -1.717393e-001, 3.056345e-001, 3.785248e-003
16204, -1.712698e-001, 3.047531e-001, 3.785248e-003
16205, -1.708003e-001, 3.038717e-001, 3.785248e-003
16206, -1.703309e-001, 3.029903e-001, 3.785248e-003
16207, -1.698614e-001, 3.021090e-001, 3.785248e-003
16208, -1.693919e-001, 3.012276e-001, 3.785248e-003
16209, -1.689224e-001, 3.003462e-001, 3.785248e-003
16210, -1.684529e-001, 2.994648e-001, 3.785248e-003
16211, -1.679834e-001, 2.985834e-001, 3.785248e-003
16212, -1.675140e-001, 2.977020e-001, 3.785248e-003
16213, -1.670445e-001, 2.968207e-001, 3.785248e-003
16214, -1.665750e-001, 2.959393e-001, 3.785248e-003
16215, -1.661055e-001, 2.950579e-001, 3.785248e-003
16216, -1.656360e-001, 2.941765e-001, 3.785248e-003
16217, -1.651666e-001, 2.932951e-001, 3.785248e-003
16218, -1.646971e-001, 2.924137e-001, 3.785248e-003
16219, -1.642276e-001, 2.915324e-001, 3.785248e-003
16220, -1.637581e-001, 2.906510e-001, 3.785248e-003
16221, -1.632886e-001, 2.897696e-001, 3.785248e-003
16222, -1.628191e-001, 2.888882e-001, 3.785248e-003
16223, -1.623497e-001, 2.880068e-001, 3.785248e-003
16224, -1.618802e-001, 2.871254e-001, 3.785248e-003
16225, -1.614107e-001, 2.862440e-001, 3.785248e-003
16226, -1.609412e-001, 2.853627e-001, 3.785248e-003
16227, -1.604717e-001, 2.844813e-001, 3.785248e-003
16228, -1.600022e-001, 2.835999e-001, 3.785248e-003
16229, -1.595328e-001, 2.827185e-001, 3.785248e-003
16230, -1.590633e-001, 2.818371e-001, 3.785248e-003
16231, -1.585938e-001, 2.809557e-001, 3.785248e-003
16232, -1.581243e-001, 2.800744e-001, 3.785248e-003
16233, -1.576548e-001, 2.791930e-001, 3.785248e-003
16234, -1.571853e-001, 2.783116e-001, 3.785248e-003
16235, -1.567159e-001, 2.774302e-001, 3.785248e-003
16236, -1.562464e-001, 2.765488e-001, 3.785248e-003
16237, -1.557769e-001, 2.756674e-001, 3.785248e-003
16238, -1.553074e-001, 2.747861e-001, 3.785248e-003
16239, -1.548379e-001, 2.739047e-001, 3.785248e-003
16240, -1.543685e-001, 2.730233e-001, 3.785248e-003
16241, -1.538990e-001, 2.721419e-001, 3.785248e-003
16242, -1.534295e-001, 2.712605e-001, 3.785248e-003
16243, -1.529600e-001, 2.703791e-001, 3.785248e-003
16244, -1.524905e-001, 2.694978e-001, 3.785248e-003
16245, -1.520210e-001, 2.686164e-001, 3.785248e-003
16246, -1.515516e-001, 2.677350e-001, 3.785248e-003
16247, -1.510821e-001, 2.668536e-001, 3.785248e-003
16248, -1.506126e-001, 2.659722e-001, 3.785248e-003
16249, -1.501431e-001, 2.650908e-001, 3.785248e-003
16250, -1.496736e-001, 2.642095e-001, 3.785248e-003
16251, -1.492041e-001, 2.633281e-001, 3.785246e-003
16252, -1.487346e-001, 2.624467e-001, 3.785287e-003
16253, -1.482644e-001, 2.615651e-001, 3.786182e-003
16254, -1.477898e-001, 2.606835e-001, 3.792978e-003
16255, -1.472990e-001, 2.598027e-001, 3.822531e-003
16256, -1.467599e-001, 2.589150e-001, 3.910687e-003
16257, -1.460318e-001, 2.578866e-001, 4.137222e-003
16258, -1.344067e-001, 2.439764e-001, 6.729858e-003
16259, -1.348721e-001, 2.452881e-001, 6.785395e-003
16260, -1.355101e-001, 2.465510e-001, 6.793085e-003
16261, -1.361502e-001, 2.477271e-001, 6.790099e-003
16262, -1.368076e-001, 2.488574e-001, 6.777677e-003
16263, -1.375318e-001, 2.499459e-001, 6.743481e-003
16264, -1.382911e-001, 2.509574e-001, 6.686244e-003
16265, -1.390604e-001, 2.519169e-001, 6.611290e-003
16266, -1.398565e-001, 2.528495e-001, 6.513374e-003
16267, -1.406940e-001, 2.537594e-001, 6.382005e-003
16268, -1.415809e-001, 2.546488e-001, 6.204826e-003
16269, -1.425282e-001, 2.555160e-001, 5.961558e-003
16270, -1.435401e-001, 2.563485e-001, 5.621966e-003
16271, -1.447008e-001, 2.572505e-001, 5.122388e-003
16272, -1.292121e-001, 2.495714e-001, 4.585213e-003
16273, -1.287410e-001, 2.486876e-001, 4.584832e-003
16274, -1.277985e-001, 2.469193e-001, 4.584237e-003
16275, -1.301530e-001, 2.513384e-001, 4.584816e-003
16276, -1.296832e-001, 2.504542e-001, 4.586076e-003
16277, -1.310951e-001, 2.531049e-001, 4.586026e-003
16278, -1.306223e-001, 2.522210e-001, 4.584002e-003
16279, -1.284221e-001, 2.465873e-001, 5.290644e-003
16280, -1.291300e-001, 2.462138e-001, 5.889618e-003
16281, -1.299074e-001, 2.458103e-001, 6.367666e-003
16282, -1.307323e-001, 2.453874e-001, 6.713979e-003
16283, -1.315805e-001, 2.449563e-001, 6.923923e-003
16284, -1.324335e-001, 2.445338e-001, 6.999568e-003
16285, -1.333813e-001, 2.443178e-001, 6.946934e-003
16286, -1.282697e-001, 2.478034e-001, 4.584513e-003
16287, -1.320405e-001, 2.548777e-001, 4.587196e-003
16288, -1.315686e-001, 2.539909e-001, 4.587628e-003
16289, -1.325133e-001, 2.557639e-001, 4.587928e-003
16290, -1.329867e-001, 2.566512e-001, 4.588690e-003
16291, -1.334563e-001, 2.575364e-001, 4.586709e-003
16292, -1.339229e-001, 2.584192e-001, 4.583035e-003
16293, -1.343916e-001, 2.593014e-001, 4.581819e-003
16294, -1.348624e-001, 2.601831e-001, 4.582971e-003
16295, -1.353339e-001, 2.610661e-001, 4.584110e-003
16296, -1.358052e-001, 2.619498e-001, 4.584702e-003
16297, -1.362762e-001, 2.628338e-001, 4.584853e-003
16298, -1.367472e-001, 2.637179e-001, 4.584901e-003
16299, -1.372182e-001, 2.646021e-001, 4.584926e-003
16300, -1.376891e-001, 2.654862e-001, 4.584944e-003
16301, -1.381600e-001, 2.663703e-001, 4.584952e-003
16302, -1.386310e-001, 2.672544e-001, 4.584956e-003
16303, -1.391019e-001, 2.681385e-001, 4.584957e-003
16304, -1.395729e-001, 2.690227e-001, 4.584958e-003
16305, -1.400438e-001, 2.699068e-001, 4.584958e-003
16306, -1.405148e-001, 2.707909e-001, 4.584958e-003
16307, -1.409857e-001, 2.716751e-001, 4.584958e-003
16308, -1.414567e-001, 2.725592e-001, 4.584958e-003
16309, -1.419276e-001, 2.734434e-001, 4.584958e-003
16310, -1.423986e-001, 2.743275e-001, 4.584958e-003
16311, -1.428695e-001, 2.752117e-001, 4.584958e-003
16312, -1.433405e-001, 2.760958e-001, 4.584958e-003
16313, -1.438115e-001, 2.769799e-001, 4.584958e-003
16314, -1.442824e-001, 2.778641e-001, 4.584958e-003
16315, -1.447534e-001, 2.787482e-001, 4.584958e-003
16316, -1.452243e-001, 2.796324e-001, 4.584958e-003
16317, -1.456953e-001, 2.805165e-001, 4.584958e-003
16318, -1.461662e-001, 2.814006e-001, 4.584958e-003
16319, -1.466372e-001, 2.822848e-001, 4.584958e-003
16320, -1.471081e-001, 2.831689e-001, 4.584958e-003
16321, -1.475791e-001, 2.840531e-001, 4.584958e-003
16322, -1.480500e-001, 2.849372e-001, 4.584958e-003
16323, -1.485210e-001, 2.858214e-001, 4.584958e-003
16324, -1.489919e-001, 2.867055e-001, 4.584958e-003
16325, -1.494629e-001, 2.875896e-001, 4.584958e-003
16326, -1.499338e-001, 2.884738e-001, 4.584958e-003
16327, -1.504048e-001, 2.893579e-001, 4.584958e-003
16328, -1.508757e-001, 2.902421e-001, 4.584958e-003
16329, -1.513467e-001, 2.911262e-001, 4.584958e-003
16330, -1.518176e-001, 2.920103e-001, 4.584958e-003
16331, -1.522886e-001, 2.928945e-001, 4.584958e-003
16332, -1.527595e-001, 2.937786e-001, 4.584958e-003
16333, -1.532305e-001, 2.946628e-001, 4.584958e-003
16334, -1.537014e-001, 2.955469e-001, 4.584958e-003
16335, -1.541724e-001, 2.964310e-001, 4.584958e-003
16336, -1.546433e-001, 2.973152e-001, 4.584958e-003
16337, -1.551143e-001, 2.981993e-001, 4.584958e-003
16338, -1.555852e-001, 2.990835e-001, 4.584958e-003
16339, -1.560562e-001, 2.999676e-001, 4.584958e-003
16340, -1.565271e-001, 3.008518e-001, 4.584958e-003
16341, -1.569981e-001, 3.017359e-001, 4.584958e-003
16342, -1.574690e-001, 3.026200e-001, 4.584958e-003
16343, -1.579400e-001, 3.035042e-001, 4.584958e-003
16344, -1.584109e-001, 3.043883e-001, 4.584958e-003
16345, -1.588819e-001, 3.052725e-001, 4.584958e-003
16346, -1.593528e-001, 3.061566e-001, 4.584958e-003
16347, -1.598238e-001, 3.070407e-001, 4.584958e-003
16348, -1.602947e-001, 3.079249e-001, 4.584958e-003
16349, -1.607657e-001, 3.088090e-001, 4.584958e-003
16350, -1.612366e-001, 3.096932e-001, 4.584958e-003
16351, -1.617076e-001, 3.105773e-001, 4.584958e-003
16352, -1.621786e-001, 3.114615e-001, 4.584958e-003
16353, -1.626495e-001, 3.123456e-001, 4.584958e-003
16354, -1.631205e-001, 3.132297e-001, 4.584958e-003
16355, -1.635914e-001, 3.141139e-001, 4.584958e-003
16356, -1.640624e-001, 3.149980e-001, 4.584958e-003
16357, -1.645333e-001, 3.158822e-001, 4.584958e-003
16358, -1.650043e-001, 3.167663e-001, 4.584958e-003
16359, -1.654752e-001, 3.176504e-001, 4.584958e-003
16360, -1.659462e-001, 3.185346e-001, 4.584958e-003
16361, -1.664171e-001, 3.194187e-001, 4.584958e-003
16362, -1.668881e-001, 3.203029e-001, 4.584958e-003
16363, -1.673590e-001, 3.211870e-001, 4.584958e-003
16364, -1.678300e-001, 3.220712e-001, 4.584958e-003
16365, -1.683009e-001, 3.229553e-001, 4.584958e-003
16366, -1.687719e-001, 3.238394e-001, 4.584958e-003
16367, -1.692428e-001, 3.247236e-001, 4.584958e-003
16368, -1.697138e-001, 3.256077e-001, 4.584958e-003
16369, -1.701847e-001, 3.264919e-001, 4.584958e-003
16370, -1.706557e-001, 3.273760e-001, 4.584958e-003
16371, -1.711266e-001, 3.282601e-001, 4.584958e-003
16372, -1.715976e-001, 3.291443e-001, 4.584958e-003
16373, -1.720685e-001, 3.300284e-001, 4.584958e-003
16374, -1.725395e-001, 3.309126e-001, 4.584958e-003
16375, -1.730104e-001, 3.317967e-001, 4.584958e-003
16376, -1.734814e-001, 3.326809e-001, 4.584958e-003
16377, -1.739523e-001, 3.335650e-001, 4.584958e-003
16378, -1.744233e-001, 3.344491e-001, 4.584958e-003
16379, -1.748942e-001, 3.353333e-001, 4.584958e-003
16380, -1.753652e-001, 3.362174e-001, 4.584958e-003
16381, -1.758361e-001, 3.371016e-001, 4.584958e-003
16382, -1.763071e-001, 3.379857e-001, 4.584958e-003
16383, -1.767780e-001, 3.388698e-001, 4.584958e-003
16384, -1.772490e-001, 3.397540e-001, 4.584958e-003
16385, -1.777199e-001, 3.406381e-001, 4.584958e-003
16386, -1.781909e-001, 3.415223e-001, 4.584958e-003
16387, -1.786618e-001, 3.424064e-001, 4.584958e-003
16388, -1.791328e-001, 3.432905e-001, 4.584958e-003
16389, -1.796037e-001, 3.441747e-001, 4.584958e-003
16390, -1.800747e-001, 3.450588e-001, 4.584958e-003
16391, -1.805457e-001, 3.459430e-001, 4.584958e-003
16392, -1.810166e-001, 3.468271e-001, 4.584958e-003
16393, -1.814876e-001, 3.477113e-001, 4.584958e-003
16394, -1.819585e-001, 3.485954e-001, 4.584958e-003
16395, -1.824295e-001, 3.494795e-001, 4.584958e-003
16396, -1.829004e-001, 3.503637e-001, 4.584958e-003
16397, -1.833714e-001, 3.512478e-001, 4.584958e-003
16398, -1.838423e-001, 3.521320e-001, 4.584958e-003
16399, -1.843133e-001, 3.530161e-001, 4.584958e-003
16400, -1.847842e-001, 3.539002e-001, 4.584958e-003
16401, -1.852552e-001, 3.547844e-001, 4.584958e-003
16402, -1.857261e-001, 3.556685e-001, 4.584958e-003
16403, -1.861971e-001, 3.565527e-001, 4.584958e-003
16404, -1.866680e-001, 3.574368e-001, 4.584958e-003
16405, -1.871390e-001, 3.583210e-001, 4.584958e-003
16406, -1.876099e-001, 3.592051e-001, 4.584958e-003
16407, -1.880809e-001, 3.600892e-001, 4.584958e-003
16408, -1.885518e-001, 3.609734e-001, 4.584958e-003
16409, -1.890228e-001, 3.618575e-001, 4.584958e-003
16410, -1.894937e-001, 3.627417e-001, 4.584958e-003
16411, -1.899647e-001, 3.636258e-001, 4.584958e-003
16412, -1.904356e-001, 3.645099e-001, 4.584958e-003
16413, -1.909066e-001, 3.653941e-001, 4.584958e-003
16414, -1.913775e-001, 3.662782e-001, 4.584958e-003
16415, -1.918485e-001, 3.671624e-001, 4.584958e-003
16416, -1.923194e-001, 3.680465e-001, 4.584958e-003
16417, -1.927904e-001, 3.689307e-001, 4.584958e-003
16418, -1.932613e-001, 3.698148e-001, 4.584958e-003
16419, -1.937323e-001, 3.706989e-001, 4.584958e-003
16420, -1.942032e-001, 3.715831e-001, 4.584958e-003
16421, -1.946742e-001, 3.724672e-001, 4.584958e-003
16422, -1.951451e-001, 3.733514e-001, 4.584958e-003
16423, -1.956161e-001, 3.742355e-001, 4.584958e-003
16424, -1.960870e-001, 3.751196e-001, 4.584958e-003
16425, -1.965580e-001, 3.760038e-001, 4.584958e-003
16426, -1.970289e-001, 3.768879e-001, 4.584958e-003
16427, -1.974999e-001, 3.777721e-001, 4.584958e-003
16428, -1.979709e-001, 3.786562e-001, 4.584958e-003
16429, -1.984418e-001, 3.795404e-001, 4.584958e-003
16430, -1.989128e-001, 3.804245e-001, 4.584958e-003
16431, -1.993837e-001, 3.813086e-001, 4.584958e-003
16432, -1.998547e-001, 3.821928e-001, 4.584958e-003
16433, -2.003256e-001, 3.830769e-001, 4.584958e-003
16434, -2.007966e-001, 3.839611e-001, 4.584958e-003
16435, -2.012675e-001, 3.848452e-001, 4.584958e-003
16436, -2.017385e-001, 3.857293e-001, 4.584958e-003
16437, -2.022094e-001, 3.866135e-001, 4.584957e-003
16438, -2.026804e-001, 3.874976e-001, 4.584957e-003
16439, -2.031513e-001, 3.883818e-001, 4.584957e-003
16440, -2.036223e-001, 3.892659e-001, 4.584957e-003
16441, -2.040932e-001, 3.901501e-001, 4.584957e-003
16442, -2.045642e-001, 3.910342e-001, 4.584957e-003
16443, -2.050351e-001, 3.919183e-001, 4.584957e-003
16444, -2.055061e-001, 3.928025e-001, 4.584957e-003
16445, -2.059770e-001, 3.936866e-001, 4.584957e-003
16446, -2.064480e-001, 3.945708e-001, 4.584957e-003
16447, -2.069189e-001, 3.954549e-001, 4.584957e-003
16448, -2.073899e-001, 3.963390e-001, 4.584957e-003
16449, -2.078608e-001, 3.972232e-001, 4.584957e-003
16450, -2.083318e-001, 3.981073e-001, 4.584957e-003
16451, -2.088027e-001, 3.989915e-001, 4.584957e-003
16452, -2.092737e-001, 3.998756e-001, 4.584957e-003
16453, -2.097446e-001, 4.007598e-001, 4.584957e-003
16454, -2.102156e-001, 4.016439e-001, 4.584957e-003
16455, -2.106865e-001, 4.025280e-001, 4.584956e-003
16456, -2.111575e-001, 4.034122e-001, 4.584955e-003
16457, -2.116285e-001, 4.042964e-001, 4.584947e-003
16458, -2.120994e-001, 4.051806e-001, 4.584918e-003
16459, -2.125704e-001, 4.060650e-001, 4.584843e-003
16460, -2.130414e-001, 4.069494e-001, 4.584708e-003
16461, -2.135124e-001, 4.078339e-001, 4.584530e-003
16462, -2.173038e-001, 4.058183e-001, 6.928796e-003
16463, -2.164423e-001, 4.062764e-001, 6.716583e-003
16464, -2.181832e-001, 4.053505e-001, 7.000000e-003
16465, -2.156161e-001, 4.067157e-001, 6.367661e-003
16466, -2.148421e-001, 4.071271e-001, 5.889122e-003
16467, -2.141360e-001, 4.075024e-001, 5.290690e-003
16468, -2.195672e-001, 3.966982e-001, 4.584975e-003
16469, -2.200367e-001, 3.975796e-001, 4.584969e-003
16470, -2.199240e-001, 4.044242e-001, 6.716470e-003
16471, -2.190626e-001, 4.048827e-001, 6.928744e-003
16472, -2.207500e-001, 4.039846e-001, 6.367484e-003
16473, -2.215238e-001, 4.035728e-001, 5.888883e-003
16474, -2.222296e-001, 4.031972e-001, 5.290402e-003
16475, -2.228533e-001, 4.028658e-001, 4.584218e-003
16476, -2.205062e-001, 3.984609e-001, 4.584944e-003
16477, -2.209756e-001, 3.993421e-001, 4.584883e-003
16478, -2.214450e-001, 4.002230e-001, 4.584758e-003
16479, -2.219143e-001, 4.011037e-001, 4.584570e-003
16480, -2.223837e-001, 4.019846e-001, 4.584374e-003
16481, -2.190978e-001, 3.958168e-001, 4.584976e-003
16482, -2.186283e-001, 3.949355e-001, 4.584977e-003
16483, -2.181588e-001, 3.940541e-001, 4.584977e-003
16484, -2.176893e-001, 3.931727e-001, 4.584977e-003
16485, -2.172198e-001, 3.922913e-001, 4.584977e-003
16486, -2.167504e-001, 3.914099e-001, 4.584977e-003
16487, -2.162809e-001, 3.905285e-001, 4.584977e-003
16488, -2.158114e-001, 3.896472e-001, 4.584977e-003
16489, -2.153419e-001, 3.887658e-001, 4.584977e-003
16490, -2.148724e-001, 3.878844e-001, 4.584977e-003
16491, -2.144029e-001, 3.870030e-001, 4.584977e-003
16492, -2.139335e-001, 3.861216e-001, 4.584977e-003
16493, -2.134640e-001, 3.852402e-001, 4.584977e-003
16494, -2.129945e-001, 3.843589e-001, 4.584977e-003
16495, -2.125250e-001, 3.834775e-001, 4.584977e-003
16496, -2.120555e-001, 3.825961e-001, 4.584977e-003
16497, -2.115861e-001, 3.817147e-001, 4.584977e-003
16498, -2.111166e-001, 3.808333e-001, 4.584977e-003
16499, -2.106471e-001, 3.799519e-001, 4.584977e-003
16500, -2.101776e-001, 3.790705e-001, 4.584977e-003
16501, -2.097081e-001, 3.781892e-001, 4.584976e-003
16502, -2.092386e-001, 3.773078e-001, 4.584976e-003
16503, -2.087691e-001, 3.764264e-001, 4.584976e-003
16504, -2.082997e-001, 3.755450e-001, 4.584976e-003
16505, -2.078302e-001, 3.746636e-001, 4.584976e-003
16506, -2.073607e-001, 3.737822e-001, 4.584976e-003
16507, -2.068912e-001, 3.729008e-001, 4.584976e-003
16508, -2.064217e-001, 3.720195e-001, 4.584976e-003
16509, -2.059523e-001, 3.711381e-001, 4.584976e-003
16510, -2.054828e-001, 3.702567e-001, 4.584976e-003
16511, -2.050133e-001, 3.693753e-001, 4.584976e-003
16512, -2.045438e-001, 3.684939e-001, 4.584976e-003
16513, -2.040743e-001, 3.676125e-001, 4.584976e-003
16514, -2.036048e-001, 3.667311e-001, 4.584976e-003
16515, -2.031354e-001, 3.658498e-001, 4.584976e-003
16516, -2.026659e-001, 3.649684e-001, 4.584976e-003
16517, -2.021964e-001, 3.640870e-001, 4.584976e-003
16518, -2.017269e-001, 3.632056e-001, 4.584976e-003
16519, -2.012574e-001, 3.623242e-001, 4.584976e-003
16520, -2.007879e-001, 3.614428e-001, 4.584976e-003
16521, -2.003185e-001, 3.605615e-001, 4.584976e-003
16522, -1.998490e-001, 3.596801e-001, 4.584976e-003
16523, -1.993795e-001, 3.587987e-001, 4.584976e-003
16524, -1.989100e-001, 3.579173e-001, 4.584976e-003
16525, -1.984405e-001, 3.570359e-001, 4.584976e-003
16526, -1.979710e-001, 3.561545e-001, 4.584976e-003
16527, -1.975016e-001, 3.552732e-001, 4.584976e-003
16528, -1.970321e-001, 3.543918e-001, 4.584976e-003
16529, -1.965626e-001, 3.535104e-001, 4.584976e-003
16530, -1.960931e-001, 3.526290e-001, 4.584976e-003
16531, -1.956236e-001, 3.517476e-001, 4.584976e-003
16532, -1.951542e-001, 3.508662e-001, 4.584976e-003
16533, -1.946847e-001, 3.499848e-001, 4.584976e-003
16534, -1.942152e-001, 3.491035e-001, 4.584976e-003
16535, -1.937457e-001, 3.482221e-001, 4.584976e-003
16536, -1.932762e-001, 3.473407e-001, 4.584976e-003
16537, -1.928067e-001, 3.464593e-001, 4.584976e-003
16538, -1.923373e-001, 3.455779e-001, 4.584976e-003
16539, -1.918678e-001, 3.446965e-001, 4.584976e-003
16540, -1.913983e-001, 3.438152e-001, 4.584976e-003
16541, -1.909288e-001, 3.429338e-001, 4.584976e-003
16542, -1.904593e-001, 3.420524e-001, 4.584976e-003
16543, -1.899898e-001, 3.411710e-001, 4.584976e-003
16544, -1.895204e-001, 3.402896e-001, 4.584976e-003
16545, -1.890509e-001, 3.394082e-001, 4.584976e-003
16546, -1.885814e-001, 3.385268e-001, 4.584976e-003
16547, -1.881119e-001, 3.376455e-001, 4.584976e-003
16548, -1.876424e-001, 3.367641e-001, 4.584976e-003
16549, -1.871729e-001, 3.358827e-001, 4.584976e-003
16550, -1.867035e-001, 3.350013e-001, 4.584976e-003
16551, -1.862340e-001, 3.341199e-001, 4.584976e-003
16552, -1.857645e-001, 3.332385e-001, 4.584976e-003
16553, -1.852950e-001, 3.323572e-001, 4.584976e-003
16554, -1.848255e-001, 3.314758e-001, 4.584976e-003
16555, -1.843560e-001, 3.305944e-001, 4.584976e-003
16556, -1.838866e-001, 3.297130e-001, 4.584976e-003
16557, -1.834171e-001, 3.288316e-001, 4.584976e-003
16558, -1.829476e-001, 3.279502e-001, 4.584976e-003
16559, -1.824781e-001, 3.270689e-001, 4.584976e-003
16560, -1.820086e-001, 3.261875e-001, 4.584976e-003
16561, -1.815392e-001, 3.253061e-001, 4.584976e-003
16562, -1.810697e-001, 3.244247e-001, 4.584976e-003
16563, -1.806002e-001, 3.235433e-001, 4.584976e-003
16564, -1.801307e-001, 3.226619e-001, 4.584976e-003
16565, -1.796612e-001, 3.217805e-001, 4.584976e-003
16566, -1.791917e-001, 3.208992e-001, 4.584976e-003
16567, -1.787223e-001, 3.200178e-001, 4.584976e-003
16568, -1.782528e-001, 3.191364e-001, 4.584976e-003
16569, -1.777833e-001, 3.182550e-001, 4.584976e-003
16570, -1.773138e-001, 3.173736e-001, 4.584976e-003
16571, -1.768443e-001, 3.164922e-001, 4.584976e-003
16572, -1.763748e-001, 3.156109e-001, 4.584976e-003
16573, -1.759054e-001, 3.147295e-001, 4.584976e-003
16574, -1.754359e-001, 3.138481e-001, 4.584976e-003
16575, -1.749664e-001, 3.129667e-001, 4.584976e-003
16576, -1.744969e-001, 3.120853e-001, 4.584976e-003
16577, -1.740274e-001, 3.112039e-001, 4.584976e-003
16578, -1.735579e-001, 3.103225e-001, 4.584976e-003
16579, -1.730885e-001, 3.094412e-001, 4.584976e-003
16580, -1.726190e-001, 3.085598e-001, 4.584976e-003
16581, -1.721495e-001, 3.076784e-001, 4.584977e-003
16582, -1.716800e-001, 3.067970e-001, 4.584977e-003
16583, -1.712105e-001, 3.059156e-001, 4.584977e-003
16584, -1.707410e-001, 3.050342e-001, 4.584977e-003
16585, -1.702716e-001, 3.041529e-001, 4.584977e-003
16586, -1.698021e-001, 3.032715e-001, 4.584977e-003
16587, -1.693326e-001, 3.023901e-001, 4.584977e-003
16588, -1.688631e-001, 3.015087e-001, 4.584977e-003
16589, -1.683936e-001, 3.006273e-001, 4.584977e-003
16590, -1.679242e-001, 2.997459e-001, 4.584977e-003
16591, -1.674547e-001, 2.988646e-001, 4.584977e-003
16592, -1.669852e-001, 2.979832e-001, 4.584977e-003
16593, -1.665157e-001, 2.971018e-001, 4.584977e-003
16594, -1.660462e-001, 2.962204e-001, 4.584977e-003
16595, -1.655767e-001, 2.953390e-001, 4.584977e-003
16596, -1.651073e-001, 2.944576e-001, 4.584977e-003
16597, -1.646378e-001, 2.935762e-001, 4.584977e-003
16598, -1.641683e-001, 2.926949e-001, 4.584977e-003
16599, -1.636988e-001, 2.918135e-001, 4.584977e-003
16600, -1.632293e-001, 2.909321e-001, 4.584977e-003
16601, -1.627598e-001, 2.900507e-001, 4.584977e-003
16602, -1.622904e-001, 2.891693e-001, 4.584977e-003
16603, -1.618209e-001, 2.882879e-001, 4.584977e-003
16604, -1.613514e-001, 2.874066e-001, 4.584977e-003
16605, -1.608819e-001, 2.865252e-001, 4.584977e-003
16606, -1.604124e-001, 2.856438e-001, 4.584977e-003
16607, -1.599429e-001, 2.847624e-001, 4.584977e-003
16608, -1.594735e-001, 2.838810e-001, 4.584977e-003
16609, -1.590040e-001, 2.829996e-001, 4.584977e-003
16610, -1.585345e-001, 2.821182e-001, 4.584977e-003
16611, -1.580650e-001, 2.812369e-001, 4.584977e-003
16612, -1.575955e-001, 2.803555e-001, 4.584977e-003
16613, -1.571261e-001, 2.794741e-001, 4.584977e-003
16614, -1.566566e-001, 2.785927e-001, 4.584977e-003
16615, -1.561871e-001, 2.777113e-001, 4.584977e-003
16616, -1.557176e-001, 2.768299e-001, 4.584977e-003
16617, -1.552481e-001, 2.759486e-001, 4.584977e-003
16618, -1.547786e-001, 2.750672e-001, 4.584977e-003
16619, -1.543092e-001, 2.741858e-001, 4.584977e-003
16620, -1.538397e-001, 2.733044e-001, 4.584977e-003
16621, -1.533702e-001, 2.724230e-001, 4.584977e-003
16622, -1.529007e-001, 2.715416e-001, 4.584977e-003
16623, -1.524312e-001, 2.706603e-001, 4.584977e-003
16624, -1.519617e-001, 2.697789e-001, 4.584977e-003
16625, -1.514923e-001, 2.688975e-001, 4.584977e-003
16626, -1.510228e-001, 2.680161e-001, 4.584978e-003
16627, -1.505533e-001, 2.671347e-001, 4.584978e-003
16628, -1.500838e-001, 2.662533e-001, 4.584978e-003
16629, -1.496143e-001, 2.653719e-001, 4.584978e-003
16630, -1.491448e-001, 2.644906e-001, 4.584978e-003
16631, -1.486754e-001, 2.636092e-001, 4.584977e-003
16632, -1.482059e-001, 2.627278e-001, 4.584999e-003
16633, -1.477358e-001, 2.618463e-001, 4.585557e-003
16634, -1.472616e-001, 2.609657e-001, 4.590758e-003
16635, -1.467702e-001, 2.600931e-001, 4.617623e-003
16636, -1.462320e-001, 2.592530e-001, 4.707295e-003
16637, -1.455906e-001, 2.585017e-001, 4.931460e-003
16638, -1.336683e-001, 2.457171e-001, 6.985146e-003
16639, -1.345160e-001, 2.470300e-001, 6.975369e-003
16640, -1.351804e-001, 2.482266e-001, 6.973317e-003
16641, -1.358402e-001, 2.494509e-001, 6.972719e-003
16642, -1.366492e-001, 2.505910e-001, 6.954668e-003
16643, -1.374923e-001, 2.516038e-001, 6.918762e-003
16644, -1.383028e-001, 2.525673e-001, 6.873320e-003
16645, -1.391423e-001, 2.535203e-001, 6.810293e-003
16646, -1.400357e-001, 2.544461e-001, 6.716507e-003
16647, -1.409764e-001, 2.553471e-001, 6.583510e-003
16648, -1.419741e-001, 2.562178e-001, 6.393661e-003
16649, -1.430031e-001, 2.570106e-001, 6.126970e-003
16650, -1.439546e-001, 2.576583e-001, 5.799036e-003
16651, -1.298375e-001, 2.492393e-001, 5.292758e-003
16652, -1.293661e-001, 2.483571e-001, 5.291621e-003
16653, -1.307723e-001, 2.510038e-001, 5.288854e-003
16654, -1.303096e-001, 2.501181e-001, 5.295799e-003
16655, -1.312326e-001, 2.518792e-001, 5.284233e-003
16656, -1.288943e-001, 2.474724e-001, 5.291149e-003
16657, -1.296036e-001, 2.471023e-001, 5.889801e-003
16658, -1.303809e-001, 2.467060e-001, 6.366217e-003
16659, -1.312039e-001, 2.462926e-001, 6.711226e-003
16660, -1.320502e-001, 2.458668e-001, 6.921902e-003
16661, -1.326945e-001, 2.453687e-001, 6.995890e-003
16662, -1.449285e-001, 2.581339e-001, 5.313935e-003
16663, -2.217600e-001, 4.023159e-001, 5.290550e-003
16664, -2.210540e-001, 4.026913e-001, 5.888996e-003
16665, -2.175351e-001, 3.943862e-001, 5.291323e-003
16666, -2.180045e-001, 3.952675e-001, 5.291323e-003
16667, -1.317146e-001, 2.527574e-001, 5.295158e-003
16668, -1.331620e-001, 2.554484e-001, 5.305812e-003
16669, -1.326825e-001, 2.545509e-001, 5.304709e-003
16670, -1.345471e-001, 2.581183e-001, 5.277443e-003
16671, -1.341041e-001, 2.572428e-001, 5.295357e-003
16672, -1.350056e-001, 2.589908e-001, 5.272634e-003
16673, -1.354778e-001, 2.598608e-001, 5.279422e-003
16674, -1.359537e-001, 2.607388e-001, 5.285726e-003
16675, -1.364280e-001, 2.616204e-001, 5.289354e-003
16676, -1.368996e-001, 2.625038e-001, 5.290106e-003
16677, -1.373709e-001, 2.633877e-001, 5.290460e-003
16678, -1.378421e-001, 2.642714e-001, 5.290866e-003
16679, -1.383131e-001, 2.651549e-001, 5.291111e-003
16680, -1.387839e-001, 2.660387e-001, 5.291222e-003
16681, -1.392548e-001, 2.669225e-001, 5.291274e-003
16682, -1.397257e-001, 2.678065e-001, 5.291295e-003
16683, -1.401966e-001, 2.686906e-001, 5.291302e-003
16684, -1.406676e-001, 2.695747e-001, 5.291305e-003
16685, -1.411385e-001, 2.704589e-001, 5.291305e-003
16686, -1.416095e-001, 2.713430e-001, 5.291305e-003
16687, -1.420804e-001, 2.722271e-001, 5.291305e-003
16688, -1.425514e-001, 2.731113e-001, 5.291305e-003
16689, -1.430223e-001, 2.739954e-001, 5.291305e-003
16690, -1.434933e-001, 2.748796e-001, 5.291306e-003
16691, -1.439642e-001, 2.757637e-001, 5.291306e-003
16692, -1.444352e-001, 2.766478e-001, 5.291306e-003
16693, -1.449061e-001, 2.775320e-001, 5.291306e-003
16694, -1.453771e-001, 2.784161e-001, 5.291306e-003
16695, -1.458480e-001, 2.793003e-001, 5.291306e-003
16696, -1.463190e-001, 2.801844e-001, 5.291306e-003
16697, -1.467899e-001, 2.810686e-001, 5.291306e-003
16698, -1.472609e-001, 2.819527e-001, 5.291306e-003
16699, -1.477318e-001, 2.828368e-001, 5.291306e-003
16700, -1.482028e-001, 2.837210e-001, 5.291306e-003
16701, -1.486737e-001, 2.846051e-001, 5.291306e-003
16702, -1.491447e-001, 2.854893e-001, 5.291306e-003
16703, -1.496156e-001, 2.863734e-001, 5.291306e-003
16704, -1.500866e-001, 2.872575e-001, 5.291306e-003
16705, -1.505576e-001, 2.881417e-001, 5.291306e-003
16706, -1.510285e-001, 2.890258e-001, 5.291306e-003
16707, -1.514995e-001, 2.899100e-001, 5.291306e-003
16708, -1.519704e-001, 2.907941e-001, 5.291306e-003
16709, -1.524414e-001, 2.916782e-001, 5.291306e-003
16710, -1.529123e-001, 2.925624e-001, 5.291306e-003
16711, -1.533833e-001, 2.934465e-001, 5.291306e-003
16712, -1.538542e-001, 2.943307e-001, 5.291306e-003
16713, -1.543252e-001, 2.952148e-001, 5.291306e-003
16714, -1.547961e-001, 2.960989e-001, 5.291306e-003
16715, -1.552671e-001, 2.969831e-001, 5.291306e-003
16716, -1.557380e-001, 2.978672e-001, 5.291306e-003
16717, -1.562090e-001, 2.987514e-001, 5.291306e-003
16718, -1.566799e-001, 2.996355e-001, 5.291306e-003
16719, -1.571509e-001, 3.005196e-001, 5.291306e-003
16720, -1.576218e-001, 3.014038e-001, 5.291306e-003
16721, -1.580928e-001, 3.022879e-001, 5.291306e-003
16722, -1.585637e-001, 3.031721e-001, 5.291306e-003
16723, -1.590347e-001, 3.040562e-001, 5.291306e-003
16724, -1.595056e-001, 3.049404e-001, 5.291306e-003
16725, -1.599766e-001, 3.058245e-001, 5.291306e-003
16726, -1.604475e-001, 3.067086e-001, 5.291306e-003
16727, -1.609185e-001, 3.075928e-001, 5.291306e-003
16728, -1.613894e-001, 3.084769e-001, 5.291306e-003
16729, -1.618604e-001, 3.093611e-001, 5.291306e-003
16730, -1.623313e-001, 3.102452e-001, 5.291306e-003
16731, -1.628023e-001, 3.111293e-001, 5.291306e-003
16732, -1.632732e-001, 3.120135e-001, 5.291306e-003
16733, -1.637442e-001, 3.128976e-001, 5.291306e-003
16734, -1.642151e-001, 3.137818e-001, 5.291306e-003
16735, -1.646861e-001, 3.146659e-001, 5.291306e-003
16736, -1.651570e-001, 3.155500e-001, 5.291306e-003
16737, -1.656280e-001, 3.164342e-001, 5.291306e-003
16738, -1.660989e-001, 3.173183e-001, 5.291306e-003
16739, -1.665699e-001, 3.182025e-001, 5.291306e-003
16740, -1.670408e-001, 3.190866e-001, 5.291306e-003
16741, -1.675118e-001, 3.199707e-001, 5.291306e-003
16742, -1.679827e-001, 3.208549e-001, 5.291306e-003
16743, -1.684537e-001, 3.217390e-001, 5.291306e-003
16744, -1.689246e-001, 3.226232e-001, 5.291306e-003
16745, -1.693956e-001, 3.235073e-001, 5.291306e-003
16746, -1.698665e-001, 3.243914e-001, 5.291306e-003
16747, -1.703375e-001, 3.252756e-001, 5.291306e-003
16748, -1.708084e-001, 3.261597e-001, 5.291306e-003
16749, -1.712794e-001, 3.270439e-001, 5.291306e-003
16750, -1.717503e-001, 3.279280e-001, 5.291306e-003
16751, -1.722213e-001, 3.288122e-001, 5.291306e-003
16752, -1.726922e-001, 3.296963e-001, 5.291306e-003
16753, -1.731632e-001, 3.305804e-001, 5.291306e-003
16754, -1.736341e-001, 3.314646e-001, 5.291306e-003
16755, -1.741051e-001, 3.323487e-001, 5.291306e-003
16756, -1.745760e-001, 3.332329e-001, 5.291306e-003
16757, -1.750470e-001, 3.341170e-001, 5.291306e-003
16758, -1.755179e-001, 3.350011e-001, 5.291306e-003
16759, -1.759889e-001, 3.358853e-001, 5.291306e-003
16760, -1.764599e-001, 3.367694e-001, 5.291306e-003
16761, -1.769308e-001, 3.376536e-001, 5.291306e-003
16762, -1.774018e-001, 3.385377e-001, 5.291306e-003
16763, -1.778727e-001, 3.394218e-001, 5.291306e-003
16764, -1.783437e-001, 3.403060e-001, 5.291306e-003
16765, -1.788146e-001, 3.411901e-001, 5.291306e-003
16766, -1.792856e-001, 3.420743e-001, 5.291306e-003
16767, -1.797565e-001, 3.429584e-001, 5.291306e-003
16768, -1.802275e-001, 3.438425e-001, 5.291306e-003
16769, -1.806984e-001, 3.447267e-001, 5.291306e-003
16770, -1.811694e-001, 3.456108e-001, 5.291306e-003
16771, -1.816403e-001, 3.464950e-001, 5.291306e-003
16772, -1.821113e-001, 3.473791e-001, 5.291306e-003
16773, -1.825822e-001, 3.482632e-001, 5.291306e-003
16774, -1.830532e-001, 3.491474e-001, 5.291306e-003
16775, -1.835241e-001, 3.500315e-001, 5.291306e-003
16776, -1.839951e-001, 3.509157e-001, 5.291306e-003
16777, -1.844660e-001, 3.517998e-001, 5.291306e-003
16778, -1.849370e-001, 3.526840e-001, 5.291306e-003
16779, -1.854079e-001, 3.535681e-001, 5.291306e-003
16780, -1.858789e-001, 3.544522e-001, 5.291306e-003
16781, -1.863498e-001, 3.553364e-001, 5.291306e-003
16782, -1.868208e-001, 3.562205e-001, 5.291306e-003
16783, -1.872917e-001, 3.571047e-001, 5.291306e-003
16784, -1.877627e-001, 3.579888e-001, 5.291306e-003
16785, -1.882336e-001, 3.588729e-001, 5.291306e-003
16786, -1.887046e-001, 3.597571e-001, 5.291306e-003
16787, -1.891755e-001, 3.606412e-001, 5.291306e-003
16788, -1.896465e-001, 3.615254e-001, 5.291306e-003
16789, -1.901174e-001, 3.624095e-001, 5.291306e-003
16790, -1.905884e-001, 3.632936e-001, 5.291306e-003
16791, -1.910593e-001, 3.641778e-001, 5.291306e-003
16792, -1.915303e-001, 3.650619e-001, 5.291306e-003
16793, -1.920012e-001, 3.659461e-001, 5.291306e-003
16794, -1.924722e-001, 3.668302e-001, 5.291306e-003
16795, -1.929431e-001, 3.677143e-001, 5.291306e-003
16796, -1.934141e-001, 3.685985e-001, 5.291306e-003
16797, -1.938850e-001, 3.694826e-001, 5.291306e-003
16798, -1.943560e-001, 3.703668e-001, 5.291306e-003
16799, -1.948269e-001, 3.712509e-001, 5.291306e-003
16800, -1.952979e-001, 3.721350e-001, 5.291306e-003
16801, -1.957688e-001, 3.730192e-001, 5.291306e-003
16802, -1.962398e-001, 3.739033e-001, 5.291306e-003
16803, -1.967107e-001, 3.747875e-001, 5.291306e-003
16804, -1.971817e-001, 3.756716e-001, 5.291306e-003
16805, -1.976526e-001, 3.765557e-001, 5.291306e-003
16806, -1.981236e-001, 3.774399e-001, 5.291306e-003
16807, -1.985945e-001, 3.783240e-001, 5.291306e-003
16808, -1.990655e-001, 3.792082e-001, 5.291306e-003
16809, -1.995364e-001, 3.800923e-001, 5.291306e-003
16810, -2.000074e-001, 3.809765e-001, 5.291306e-003
16811, -2.004783e-001, 3.818606e-001, 5.291306e-003
16812, -2.009493e-001, 3.827447e-001, 5.291306e-003
16813, -2.014202e-001, 3.836289e-001, 5.291306e-003
16814, -2.018912e-001, 3.845131e-001, 5.291305e-003
16815, -2.023622e-001, 3.853973e-001, 5.291300e-003
16816, -2.028332e-001, 3.862815e-001, 5.291294e-003
16817, -2.033042e-001, 3.871657e-001, 5.291290e-003
16818, -2.037751e-001, 3.880499e-001, 5.291288e-003
16819, -2.042461e-001, 3.889340e-001, 5.291287e-003
16820, -2.047170e-001, 3.898181e-001, 5.291287e-003
16821, -2.051880e-001, 3.907023e-001, 5.291287e-003
16822, -2.056589e-001, 3.915864e-001, 5.291286e-003
16823, -2.061299e-001, 3.924705e-001, 5.291286e-003
16824, -2.066008e-001, 3.933547e-001, 5.291286e-003
16825, -2.070718e-001, 3.942388e-001, 5.291286e-003
16826, -2.075427e-001, 3.951229e-001, 5.291286e-003
16827, -2.080136e-001, 3.960071e-001, 5.291286e-003
16828, -2.084846e-001, 3.968912e-001, 5.291286e-003
16829, -2.089555e-001, 3.977753e-001, 5.291286e-003
16830, -2.094265e-001, 3.986594e-001, 5.291286e-003
16831, -2.098974e-001, 3.995436e-001, 5.291286e-003
16832, -2.103684e-001, 4.004277e-001, 5.291286e-003
16833, -2.108393e-001, 4.013119e-001, 5.291285e-003
16834, -2.113103e-001, 4.021960e-001, 5.291282e-003
16835, -2.117812e-001, 4.030802e-001, 5.291273e-003
16836, -2.122522e-001, 4.039645e-001, 5.291245e-003
16837, -2.127232e-001, 4.048488e-001, 5.291178e-003
16838, -2.131942e-001, 4.057334e-001, 5.291054e-003
16839, -2.136652e-001, 4.066179e-001, 5.290879e-003
16840, -2.143713e-001, 4.062427e-001, 5.889305e-003
16841, -2.184740e-001, 3.961489e-001, 5.291321e-003
16842, -2.189435e-001, 3.970303e-001, 5.291313e-003
16843, -2.194130e-001, 3.979116e-001, 5.291283e-003
16844, -2.177130e-001, 4.044676e-001, 7.000000e-003
16845, -2.168335e-001, 4.049348e-001, 6.928829e-003
16846, -2.159718e-001, 4.053925e-001, 6.716667e-003
16847, -2.151454e-001, 4.058314e-001, 6.367802e-003
16848, -2.194540e-001, 4.035421e-001, 6.716499e-003
16849, -2.185925e-001, 4.040002e-001, 6.928745e-003
16850, -2.203518e-001, 3.996736e-001, 5.291106e-003
16851, -2.208212e-001, 4.005544e-001, 5.290934e-003
16852, -2.202802e-001, 4.031029e-001, 6.367557e-003
16853, -2.212905e-001, 4.014351e-001, 5.290735e-003
16854, -1.322024e-001, 2.536512e-001, 5.304041e-003
16855, -2.198824e-001, 3.987927e-001, 5.291213e-003
16856, -2.170656e-001, 3.935048e-001, 5.291323e-003
16857, -2.165961e-001, 3.926234e-001, 5.291323e-003
16858, -2.161266e-001, 3.917420e-001, 5.291323e-003
16859, -2.156571e-001, 3.908606e-001, 5.291323e-003
16860, -2.151876e-001, 3.899792e-001, 5.291323e-003
16861, -2.147182e-001, 3.890979e-001, 5.291323e-003
16862, -2.142487e-001, 3.882165e-001, 5.291323e-003
16863, -2.137792e-001, 3.873351e-001, 5.291323e-003
16864, -2.133097e-001, 3.864537e-001, 5.291323e-003
16865, -2.128402e-001, 3.855723e-001, 5.291323e-003
16866, -2.123707e-001, 3.846909e-001, 5.291323e-003
16867, -2.119013e-001, 3.838095e-001, 5.291323e-003
16868, -2.114318e-001, 3.829282e-001, 5.291323e-003
16869, -2.109623e-001, 3.820468e-001, 5.291324e-003
16870, -2.104928e-001, 3.811653e-001, 5.291322e-003
16871, -2.100233e-001, 3.802839e-001, 5.291317e-003
16872, -2.095537e-001, 3.794024e-001, 5.291312e-003
16873, -2.090842e-001, 3.785209e-001, 5.291308e-003
16874, -2.086147e-001, 3.776395e-001, 5.291306e-003
16875, -2.081452e-001, 3.767581e-001, 5.291305e-003
16876, -2.076757e-001, 3.758767e-001, 5.291304e-003
16877, -2.072063e-001, 3.749953e-001, 5.291304e-003
16878, -2.067368e-001, 3.741139e-001, 5.291304e-003
16879, -2.062673e-001, 3.732325e-001, 5.291304e-003
16880, -2.057978e-001, 3.723511e-001, 5.291304e-003
16881, -2.053283e-001, 3.714697e-001, 5.291304e-003
16882, -2.048588e-001, 3.705883e-001, 5.291304e-003
16883, -2.043893e-001, 3.697069e-001, 5.291304e-003
16884, -2.039198e-001, 3.688255e-001, 5.291304e-003
16885, -2.034503e-001, 3.679441e-001, 5.291304e-003
16886, -2.029809e-001, 3.670627e-001, 5.291304e-003
16887, -2.025114e-001, 3.661813e-001, 5.291304e-003
16888, -2.020419e-001, 3.652999e-001, 5.291304e-003
16889, -2.015724e-001, 3.644185e-001, 5.291305e-003
16890, -2.011029e-001, 3.635372e-001, 5.291305e-003
16891, -2.006334e-001, 3.626558e-001, 5.291305e-003
16892, -2.001639e-001, 3.617744e-001, 5.291305e-003
16893, -1.996944e-001, 3.608930e-001, 5.291305e-003
16894, -1.992249e-001, 3.600116e-001, 5.291305e-003
16895, -1.987555e-001, 3.591302e-001, 5.291305e-003
16896, -1.982860e-001, 3.582488e-001, 5.291305e-003
16897, -1.978165e-001, 3.573674e-001, 5.291305e-003
16898, -1.973470e-001, 3.564860e-001, 5.291305e-003
16899, -1.968775e-001, 3.556046e-001, 5.291305e-003
16900, -1.964080e-001, 3.547232e-001, 5.291306e-003
16901, -1.959385e-001, 3.538418e-001, 5.291306e-003
16902, -1.954690e-001, 3.529604e-001, 5.291306e-003
16903, -1.949995e-001, 3.520790e-001, 5.291306e-003
16904, -1.945301e-001, 3.511976e-001, 5.291306e-003
16905, -1.940606e-001, 3.503162e-001, 5.291306e-003
16906, -1.935911e-001, 3.494348e-001, 5.291306e-003
16907, -1.931216e-001, 3.485534e-001, 5.291306e-003
16908, -1.926521e-001, 3.476720e-001, 5.291306e-003
16909, -1.921826e-001, 3.467906e-001, 5.291306e-003
16910, -1.917131e-001, 3.459092e-001, 5.291306e-003
16911, -1.912436e-001, 3.450279e-001, 5.291306e-003
16912, -1.907741e-001, 3.441465e-001, 5.291306e-003
16913, -1.903047e-001, 3.432651e-001, 5.291307e-003
16914, -1.898352e-001, 3.423837e-001, 5.291307e-003
16915, -1.893657e-001, 3.415023e-001, 5.291307e-003
16916, -1.888962e-001, 3.406209e-001, 5.291307e-003
16917, -1.884267e-001, 3.397395e-001, 5.291307e-003
16918, -1.879572e-001, 3.388581e-001, 5.291307e-003
16919, -1.874877e-001, 3.379767e-001, 5.291307e-003
16920, -1.870182e-001, 3.370953e-001, 5.291307e-003
16921, -1.865488e-001, 3.362139e-001, 5.291307e-003
16922, -1.860793e-001, 3.353325e-001, 5.291308e-003
16923, -1.856098e-001, 3.344511e-001, 5.291308e-003
16924, -1.851403e-001, 3.335697e-001, 5.291308e-003
16925, -1.846708e-001, 3.326883e-001, 5.291308e-003
16926, -1.842013e-001, 3.318069e-001, 5.291308e-003
16927, -1.837318e-001, 3.309255e-001, 5.291308e-003
16928, -1.832623e-001, 3.300441e-001, 5.291308e-003
16929, -1.827928e-001, 3.291627e-001, 5.291308e-003
16930, -1.823234e-001, 3.282814e-001, 5.291309e-003
16931, -1.818539e-001, 3.274000e-001, 5.291309e-003
16932, -1.813844e-001, 3.265186e-001, 5.291309e-003
16933, -1.809149e-001, 3.256372e-001, 5.291309e-003
16934, -1.804454e-001, 3.247558e-001, 5.291309e-003
16935, -1.799759e-001, 3.238744e-001, 5.291309e-003
16936, -1.795064e-001, 3.229930e-001, 5.291309e-003
16937, -1.790369e-001, 3.221116e-001, 5.291310e-003
16938, -1.785675e-001, 3.212302e-001, 5.291310e-003
16939, -1.780980e-001, 3.203488e-001, 5.291310e-003
16940, -1.776285e-001, 3.194674e-001, 5.291310e-003
16941, -1.771590e-001, 3.185860e-001, 5.291310e-003
16942, -1.766895e-001, 3.177046e-001, 5.291310e-003
16943, -1.762200e-001, 3.168232e-001, 5.291311e-003
16944, -1.757505e-001, 3.159418e-001, 5.291311e-003
16945, -1.752810e-001, 3.150604e-001, 5.291311e-003
16946, -1.748115e-001, 3.141790e-001, 5.291311e-003
16947, -1.743421e-001, 3.132976e-001, 5.291311e-003
16948, -1.738726e-001, 3.124163e-001, 5.291311e-003
16949, -1.734031e-001, 3.115349e-001, 5.291312e-003
16950, -1.729336e-001, 3.106535e-001, 5.291312e-003
16951, -1.724641e-001, 3.097721e-001, 5.291312e-003
16952, -1.719946e-001, 3.088907e-001, 5.291312e-003
16953, -1.715251e-001, 3.080093e-001, 5.291313e-003
16954, -1.710556e-001, 3.071279e-001, 5.291313e-003
16955, -1.705862e-001, 3.062465e-001, 5.291313e-003
16956, -1.701167e-001, 3.053651e-001, 5.291313e-003
16957, -1.696472e-001, 3.044837e-001, 5.291313e-003
16958, -1.691777e-001, 3.036023e-001, 5.291314e-003
16959, -1.687082e-001, 3.027209e-001, 5.291314e-003
16960, -1.682387e-001, 3.018395e-001, 5.291314e-003
16961, -1.677692e-001, 3.009581e-001, 5.291314e-003
16962, -1.672997e-001, 3.000767e-001, 5.291315e-003
16963, -1.668302e-001, 2.991953e-001, 5.291315e-003
16964, -1.663608e-001, 2.983139e-001, 5.291315e-003
16965, -1.658913e-001, 2.974326e-001, 5.291315e-003
16966, -1.654218e-001, 2.965512e-001, 5.291316e-003
16967, -1.649523e-001, 2.956698e-001, 5.291316e-003
16968, -1.644828e-001, 2.947884e-001, 5.291316e-003
16969, -1.640133e-001, 2.939070e-001, 5.291316e-003
16970, -1.635438e-001, 2.930256e-001, 5.291317e-003
16971, -1.630743e-001, 2.921442e-001, 5.291317e-003
16972, -1.626049e-001, 2.912628e-001, 5.291317e-003
16973, -1.621354e-001, 2.903814e-001, 5.291318e-003
16974, -1.616659e-001, 2.895000e-001, 5.291318e-003
16975, -1.611964e-001, 2.886186e-001, 5.291318e-003
16976, -1.607269e-001, 2.877372e-001, 5.291318e-003
16977, -1.602574e-001, 2.868558e-001, 5.291319e-003
16978, -1.597879e-001, 2.859744e-001, 5.291319e-003
16979, -1.593184e-001, 2.850930e-001, 5.291319e-003
16980, -1.588490e-001, 2.842117e-001, 5.291320e-003
16981, -1.583795e-001, 2.833303e-001, 5.291320e-003
16982, -1.579100e-001, 2.824489e-001, 5.291320e-003
16983, -1.574405e-001, 2.815675e-001, 5.291321e-003
16984, -1.569710e-001, 2.806861e-001, 5.291321e-003
16985, -1.565015e-001, 2.798047e-001, 5.291321e-003
16986, -1.560320e-001, 2.789233e-001, 5.291322e-003
16987, -1.555625e-001, 2.780419e-001, 5.291322e-003
16988, -1.550930e-001, 2.771605e-001, 5.291323e-003
16989, -1.546236e-001, 2.762791e-001, 5.291323e-003
16990, -1.541541e-001, 2.753977e-001, 5.291323e-003
16991, -1.536846e-001, 2.745163e-001, 5.291324e-003
16992, -1.532151e-001, 2.736349e-001, 5.291324e-003
16993, -1.527456e-001, 2.727535e-001, 5.291325e-003
16994, -1.522761e-001, 2.718721e-001, 5.291325e-003
16995, -1.518066e-001, 2.709908e-001, 5.291326e-003
16996, -1.513371e-001, 2.701094e-001, 5.291326e-003
16997, -1.508677e-001, 2.692280e-001, 5.291326e-003
16998, -1.503982e-001, 2.683466e-001, 5.291327e-003
16999, -1.499287e-001, 2.674652e-001, 5.291328e-003
17000, -1.494592e-001, 2.665838e-001, 5.291329e-003
17001, -1.489897e-001, 2.657024e-001, 5.291329e-003
17002, -1.485202e-001, 2.648210e-001, 5.291329e-003
17003, -1.480507e-001, 2.639396e-001, 5.291330e-003
17004, -1.475812e-001, 2.630582e-001, 5.291345e-003
17005, -1.471114e-001, 2.621772e-001, 5.291770e-003
17006, -1.466395e-001, 2.613008e-001, 5.295650e-003
17007, -1.461634e-001, 2.604478e-001, 5.312143e-003
17008, -1.456909e-001, 2.596613e-001, 5.352326e-003
17009, -1.452633e-001, 2.590081e-001, 5.410823e-003
17010, -1.336451e-001, 2.563527e-001, 5.306844e-003
17011, -1.442211e-001, 2.583676e-001, 5.864279e-003
17012, -1.336052e-001, 2.476068e-001, 6.982948e-003
17013, -1.341236e-001, 2.487603e-001, 6.976503e-003
17014, -1.347303e-001, 2.501947e-001, 6.963701e-003
17015, -1.357268e-001, 2.513608e-001, 6.989643e-003
17016, -1.367136e-001, 2.523090e-001, 6.999858e-003
17017, -1.375297e-001, 2.532480e-001, 6.992525e-003
17018, -1.384025e-001, 2.542251e-001, 6.971197e-003
17019, -1.393617e-001, 2.551546e-001, 6.921724e-003
17020, -1.403458e-001, 2.560610e-001, 6.840382e-003
17021, -1.413866e-001, 2.569459e-001, 6.711486e-003
17022, -1.424786e-001, 2.577618e-001, 6.511486e-003
17023, -1.434918e-001, 2.584254e-001, 6.250455e-003
17024, -1.305464e-001, 2.488715e-001, 5.890028e-003
17025, -1.300758e-001, 2.479906e-001, 5.889211e-003
17026, -2.205845e-001, 4.018103e-001, 5.889150e-003
17027, -2.201150e-001, 4.009295e-001, 5.889325e-003
17028, -1.348757e-001, 2.569873e-001, 5.893564e-003
17029, -1.344464e-001, 2.560706e-001, 5.926646e-003
17030, -1.308506e-001, 2.476031e-001, 6.362905e-003
17031, -2.189842e-001, 4.026605e-001, 6.716550e-003
17032, -2.181225e-001, 4.031181e-001, 6.928756e-003
17033, -1.328122e-001, 2.467839e-001, 6.953983e-003
17034, -1.316864e-001, 2.472018e-001, 6.710772e-003
17035, -2.168289e-001, 3.947621e-001, 5.889864e-003
17036, -2.172984e-001, 3.956435e-001, 5.889860e-003
17037, -2.198105e-001, 4.022216e-001, 6.367660e-003
17038, -2.158899e-001, 3.929993e-001, 5.889863e-003
17039, -2.163594e-001, 3.938806e-001, 5.889856e-003
17040, -1.352303e-001, 2.578462e-001, 5.834391e-003
17041, -2.191762e-001, 3.991681e-001, 5.889650e-003
17042, -2.196456e-001, 4.000488e-001, 5.889489e-003
17043, -1.339440e-001, 2.551217e-001, 5.928310e-003
17044, -1.334393e-001, 2.541845e-001, 5.925289e-003
17045, -1.361500e-001, 2.595109e-001, 5.853592e-003
17046, -1.356630e-001, 2.586756e-001, 5.829033e-003
17047, -1.371304e-001, 2.612575e-001, 5.882285e-003
17048, -1.366447e-001, 2.603804e-001, 5.871700e-003
17049, -1.376027e-001, 2.621407e-001, 5.883324e-003
17050, -1.380756e-001, 2.630228e-001, 5.885040e-003
17051, -1.385491e-001, 2.639034e-001, 5.887593e-003
17052, -1.390208e-001, 2.647844e-001, 5.888973e-003
17053, -1.394917e-001, 2.656668e-001, 5.889482e-003
17054, -1.399622e-001, 2.665494e-001, 5.889697e-003
17055, -1.404329e-001, 2.674327e-001, 5.889788e-003
17056, -1.409038e-001, 2.683166e-001, 5.889823e-003
17057, -1.413747e-001, 2.692006e-001, 5.889837e-003
17058, -1.418457e-001, 2.700848e-001, 5.889836e-003
17059, -1.423166e-001, 2.709690e-001, 5.889835e-003
17060, -1.427876e-001, 2.718531e-001, 5.889833e-003
17061, -1.432585e-001, 2.727372e-001, 5.889834e-003
17062, -1.437294e-001, 2.736212e-001, 5.889838e-003
17063, -1.442003e-001, 2.745053e-001, 5.889841e-003
17064, -1.446713e-001, 2.753895e-001, 5.889844e-003
17065, -1.451422e-001, 2.762736e-001, 5.889845e-003
17066, -1.456132e-001, 2.771578e-001, 5.889845e-003
17067, -1.460842e-001, 2.780419e-001, 5.889846e-003
17068, -1.465551e-001, 2.789261e-001, 5.889846e-003
17069, -1.470261e-001, 2.798102e-001, 5.889846e-003
17070, -1.474970e-001, 2.806943e-001, 5.889846e-003
17071, -1.479679e-001, 2.815784e-001, 5.889846e-003
17072, -1.484389e-001, 2.824626e-001, 5.889846e-003
17073, -1.489098e-001, 2.833467e-001, 5.889846e-003
17074, -1.493808e-001, 2.842308e-001, 5.889846e-003
17075, -1.498517e-001, 2.851150e-001, 5.889846e-003
17076, -1.503227e-001, 2.859991e-001, 5.889846e-003
17077, -1.507936e-001, 2.868832e-001, 5.889846e-003
17078, -1.512646e-001, 2.877673e-001, 5.889846e-003
17079, -1.517355e-001, 2.886515e-001, 5.889846e-003
17080, -1.522064e-001, 2.895356e-001, 5.889846e-003
17081, -1.526774e-001, 2.904197e-001, 5.889846e-003
17082, -1.531483e-001, 2.913039e-001, 5.889845e-003
17083, -1.536193e-001, 2.921880e-001, 5.889845e-003
17084, -1.540902e-001, 2.930721e-001, 5.889845e-003
17085, -1.545612e-001, 2.939562e-001, 5.889845e-003
17086, -1.550321e-001, 2.948404e-001, 5.889845e-003
17087, -1.555031e-001, 2.957245e-001, 5.889845e-003
17088, -1.559740e-001, 2.966086e-001, 5.889845e-003
17089, -1.564449e-001, 2.974928e-001, 5.889845e-003
17090, -1.569159e-001, 2.983769e-001, 5.889845e-003
17091, -1.573868e-001, 2.992610e-001, 5.889845e-003
17092, -1.578578e-001, 3.001451e-001, 5.889845e-003
17093, -1.583287e-001, 3.010293e-001, 5.889845e-003
17094, -1.587997e-001, 3.019134e-001, 5.889845e-003
17095, -1.592706e-001, 3.027975e-001, 5.889845e-003
17096, -1.597416e-001, 3.036817e-001, 5.889845e-003
17097, -1.602125e-001, 3.045658e-001, 5.889845e-003
17098, -1.606834e-001, 3.054499e-001, 5.889845e-003
17099, -1.611544e-001, 3.063340e-001, 5.889845e-003
17100, -1.616253e-001, 3.072182e-001, 5.889845e-003
17101, -1.620963e-001, 3.081023e-001, 5.889845e-003
17102, -1.625672e-001, 3.089864e-001, 5.889845e-003
17103, -1.630382e-001, 3.098706e-001, 5.889845e-003
17104, -1.635091e-001, 3.107547e-001, 5.889845e-003
17105, -1.639801e-001, 3.116388e-001, 5.889845e-003
17106, -1.644510e-001, 3.125229e-001, 5.889845e-003
17107, -1.649219e-001, 3.134071e-001, 5.889845e-003
17108, -1.653929e-001, 3.142912e-001, 5.889845e-003
17109, -1.658638e-001, 3.151753e-001, 5.889845e-003
17110, -1.663348e-001, 3.160595e-001, 5.889845e-003
17111, -1.668057e-001, 3.169436e-001, 5.889845e-003
17112, -1.672767e-001, 3.178277e-001, 5.889845e-003
17113, -1.677476e-001, 3.187118e-001, 5.889845e-003
17114, -1.682185e-001, 3.195960e-001, 5.889845e-003
17115, -1.686895e-001, 3.204801e-001, 5.889845e-003
17116, -1.691604e-001, 3.213642e-001, 5.889845e-003
17117, -1.696314e-001, 3.222484e-001, 5.889845e-003
17118, -1.701023e-001, 3.231325e-001, 5.889845e-003
17119, -1.705733e-001, 3.240166e-001, 5.889845e-003
17120, -1.710442e-001, 3.249007e-001, 5.889845e-003
17121, -1.715152e-001, 3.257849e-001, 5.889845e-003
17122, -1.719861e-001, 3.266690e-001, 5.889845e-003
17123, -1.724570e-001, 3.275531e-001, 5.889845e-003
17124, -1.729280e-001, 3.284373e-001, 5.889845e-003
17125, -1.733989e-001, 3.293214e-001, 5.889845e-003
17126, -1.738699e-001, 3.302055e-001, 5.889845e-003
17127, -1.743408e-001, 3.310896e-001, 5.889845e-003
17128, -1.748118e-001, 3.319738e-001, 5.889845e-003
17129, -1.752827e-001, 3.328579e-001, 5.889845e-003
17130, -1.757537e-001, 3.337420e-001, 5.889845e-003
17131, -1.762246e-001, 3.346261e-001, 5.889845e-003
17132, -1.766955e-001, 3.355103e-001, 5.889845e-003
17133, -1.771665e-001, 3.363944e-001, 5.889845e-003
17134, -1.776374e-001, 3.372785e-001, 5.889845e-003
17135, -1.781084e-001, 3.381627e-001, 5.889845e-003
17136, -1.785793e-001, 3.390468e-001, 5.889845e-003
17137, -1.790503e-001, 3.399309e-001, 5.889845e-003
17138, -1.795212e-001, 3.408150e-001, 5.889845e-003
17139, -1.799922e-001, 3.416992e-001, 5.889845e-003
17140, -1.804631e-001, 3.425833e-001, 5.889845e-003
17141, -1.809340e-001, 3.434674e-001, 5.889845e-003
17142, -1.814050e-001, 3.443516e-001, 5.889845e-003
17143, -1.818759e-001, 3.452357e-001, 5.889845e-003
17144, -1.823469e-001, 3.461198e-001, 5.889845e-003
17145, -1.828178e-001, 3.470039e-001, 5.889845e-003
17146, -1.832888e-001, 3.478881e-001, 5.889845e-003
17147, -1.837597e-001, 3.487722e-001, 5.889845e-003
17148, -1.842307e-001, 3.496563e-001, 5.889845e-003
17149, -1.847016e-001, 3.505405e-001, 5.889845e-003
17150, -1.851725e-001, 3.514246e-001, 5.889845e-003
17151, -1.856435e-001, 3.523087e-001, 5.889845e-003
17152, -1.861144e-001, 3.531928e-001, 5.889845e-003
17153, -1.865854e-001, 3.540770e-001, 5.889845e-003
17154, -1.870563e-001, 3.549611e-001, 5.889845e-003
17155, -1.875273e-001, 3.558452e-001, 5.889845e-003
17156, -1.879982e-001, 3.567294e-001, 5.889845e-003
17157, -1.884692e-001, 3.576135e-001, 5.889845e-003
17158, -1.889401e-001, 3.584976e-001, 5.889845e-003
17159, -1.894110e-001, 3.593817e-001, 5.889845e-003
17160, -1.898820e-001, 3.602659e-001, 5.889845e-003
17161, -1.903529e-001, 3.611500e-001, 5.889845e-003
17162, -1.908239e-001, 3.620341e-001, 5.889845e-003
17163, -1.912948e-001, 3.629182e-001, 5.889845e-003
17164, -1.917658e-001, 3.638024e-001, 5.889845e-003
17165, -1.922367e-001, 3.646865e-001, 5.889845e-003
17166, -1.927076e-001, 3.655706e-001, 5.889845e-003
17167, -1.931786e-001, 3.664548e-001, 5.889845e-003
17168, -1.936495e-001, 3.673389e-001, 5.889845e-003
17169, -1.941205e-001, 3.682230e-001, 5.889845e-003
17170, -1.945914e-001, 3.691071e-001, 5.889845e-003
17171, -1.950624e-001, 3.699913e-001, 5.889845e-003
17172, -1.955333e-001, 3.708754e-001, 5.889845e-003
17173, -1.960043e-001, 3.717595e-001, 5.889845e-003
17174, -1.964752e-001, 3.726437e-001, 5.889845e-003
17175, -1.969461e-001, 3.735278e-001, 5.889845e-003
17176, -1.974171e-001, 3.744119e-001, 5.889845e-003
17177, -1.978880e-001, 3.752960e-001, 5.889845e-003
17178, -1.983590e-001, 3.761802e-001, 5.889845e-003
17179, -1.988299e-001, 3.770643e-001, 5.889845e-003
17180, -1.993009e-001, 3.779484e-001, 5.889845e-003
17181, -1.997718e-001, 3.788325e-001, 5.889845e-003
17182, -2.002428e-001, 3.797167e-001, 5.889845e-003
17183, -2.007137e-001, 3.806008e-001, 5.889845e-003
17184, -2.011846e-001, 3.814849e-001, 5.889845e-003
17185, -2.016556e-001, 3.823691e-001, 5.889846e-003
17186, -2.021266e-001, 3.832533e-001, 5.889842e-003
17187, -2.025977e-001, 3.841378e-001, 5.889826e-003
17188, -2.030689e-001, 3.850224e-001, 5.889801e-003
17189, -2.035400e-001, 3.859070e-001, 5.889776e-003
17190, -2.040111e-001, 3.867914e-001, 5.889758e-003
17191, -2.044821e-001, 3.876757e-001, 5.889748e-003
17192, -2.049530e-001, 3.885598e-001, 5.889744e-003
17193, -2.054239e-001, 3.894439e-001, 5.889742e-003
17194, -2.058949e-001, 3.903280e-001, 5.889740e-003
17195, -2.063658e-001, 3.912121e-001, 5.889740e-003
17196, -2.068367e-001, 3.920962e-001, 5.889740e-003
17197, -2.073076e-001, 3.929802e-001, 5.889739e-003
17198, -2.077785e-001, 3.938643e-001, 5.889739e-003
17199, -2.082494e-001, 3.947483e-001, 5.889739e-003
17200, -2.087203e-001, 3.956323e-001, 5.889740e-003
17201, -2.091912e-001, 3.965164e-001, 5.889740e-003
17202, -2.096621e-001, 3.974005e-001, 5.889739e-003
17203, -2.101330e-001, 3.982845e-001, 5.889739e-003
17204, -2.106039e-001, 3.991686e-001, 5.889739e-003
17205, -2.110749e-001, 4.000527e-001, 5.889739e-003
17206, -2.115458e-001, 4.009368e-001, 5.889737e-003
17207, -2.120167e-001, 4.018209e-001, 5.889732e-003
17208, -2.124876e-001, 4.027051e-001, 5.889716e-003
17209, -2.129586e-001, 4.035893e-001, 5.889673e-003
17210, -2.134295e-001, 4.044738e-001, 5.889588e-003
17211, -2.139004e-001, 4.053582e-001, 5.889465e-003
17212, -1.310274e-001, 2.497350e-001, 5.901903e-003
17213, -2.182374e-001, 3.974061e-001, 5.889820e-003
17214, -2.187068e-001, 3.982872e-001, 5.889749e-003
17215, -2.177679e-001, 3.965249e-001, 5.889844e-003
17216, -2.172429e-001, 4.035848e-001, 7.000000e-003
17217, -2.163631e-001, 4.040515e-001, 6.928852e-003
17218, -2.146747e-001, 4.049472e-001, 6.367925e-003
17219, -2.155012e-001, 4.045087e-001, 6.716731e-003
17220, -1.329384e-001, 2.532528e-001, 5.922735e-003
17221, -2.154204e-001, 3.921179e-001, 5.889858e-003
17222, -1.318852e-001, 2.514906e-001, 5.857791e-003
17223, -1.314647e-001, 2.506447e-001, 5.875071e-003
17224, -2.149509e-001, 3.912365e-001, 5.889861e-003
17225, -2.144815e-001, 3.903551e-001, 5.889864e-003
17226, -2.140120e-001, 3.894737e-001, 5.889862e-003
17227, -2.135425e-001, 3.885923e-001, 5.889861e-003
17228, -2.130730e-001, 3.877109e-001, 5.889862e-003
17229, -2.126035e-001, 3.868296e-001, 5.889863e-003
17230, -2.121340e-001, 3.859481e-001, 5.889861e-003
17231, -2.116645e-001, 3.850667e-001, 5.889859e-003
17232, -2.111950e-001, 3.841853e-001, 5.889860e-003
17233, -2.107255e-001, 3.833039e-001, 5.889862e-003
17234, -2.102560e-001, 3.824224e-001, 5.889858e-003
17235, -2.097863e-001, 3.815406e-001, 5.889841e-003
17236, -2.093165e-001, 3.806586e-001, 5.889815e-003
17237, -2.088468e-001, 3.797767e-001, 5.889791e-003
17238, -2.083772e-001, 3.788949e-001, 5.889774e-003
17239, -2.079075e-001, 3.780132e-001, 5.889765e-003
17240, -2.074380e-001, 3.771317e-001, 5.889760e-003
17241, -2.069684e-001, 3.762502e-001, 5.889758e-003
17242, -2.064989e-001, 3.753687e-001, 5.889758e-003
17243, -2.060294e-001, 3.744872e-001, 5.889758e-003
17244, -2.055598e-001, 3.736057e-001, 5.889758e-003
17245, -2.050903e-001, 3.727243e-001, 5.889758e-003
17246, -2.046208e-001, 3.718428e-001, 5.889758e-003
17247, -2.041513e-001, 3.709613e-001, 5.889758e-003
17248, -2.036817e-001, 3.700799e-001, 5.889758e-003
17249, -2.032122e-001, 3.691984e-001, 5.889759e-003
17250, -2.027427e-001, 3.683169e-001, 5.889759e-003
17251, -2.022731e-001, 3.674355e-001, 5.889759e-003
17252, -2.018036e-001, 3.665540e-001, 5.889759e-003
17253, -2.013341e-001, 3.656725e-001, 5.889760e-003
17254, -2.008646e-001, 3.647910e-001, 5.889760e-003
17255, -2.003950e-001, 3.639096e-001, 5.889760e-003
17256, -1.999255e-001, 3.630281e-001, 5.889760e-003
17257, -1.994560e-001, 3.621466e-001, 5.889761e-003
17258, -1.989864e-001, 3.612652e-001, 5.889761e-003
17259, -1.985169e-001, 3.603837e-001, 5.889761e-003
17260, -1.980474e-001, 3.595022e-001, 5.889761e-003
17261, -1.975779e-001, 3.586208e-001, 5.889762e-003
17262, -1.971083e-001, 3.577393e-001, 5.889762e-003
17263, -1.966388e-001, 3.568578e-001, 5.889762e-003
17264, -1.961693e-001, 3.559764e-001, 5.889763e-003
17265, -1.956997e-001, 3.550949e-001, 5.889763e-003
17266, -1.952302e-001, 3.542134e-001, 5.889763e-003
17267, -1.947607e-001, 3.533320e-001, 5.889764e-003
17268, -1.942912e-001, 3.524505e-001, 5.889764e-003
17269, -1.938216e-001, 3.515690e-001, 5.889764e-003
17270, -1.933521e-001, 3.506876e-001, 5.889765e-003
17271, -1.928826e-001, 3.498061e-001, 5.889765e-003
17272, -1.924131e-001, 3.489246e-001, 5.889765e-003
17273, -1.919435e-001, 3.480432e-001, 5.889766e-003
17274, -1.914740e-001, 3.471617e-001, 5.889766e-003
17275, -1.910045e-001, 3.462802e-001, 5.889767e-003
17276, -1.905349e-001, 3.453988e-001, 5.889767e-003
17277, -1.900654e-001, 3.445173e-001, 5.889767e-003
17278, -1.895959e-001, 3.436358e-001, 5.889768e-003
17279, -1.891264e-001, 3.427544e-001, 5.889768e-003
17280, -1.886568e-001, 3.418729e-001, 5.889769e-003
17281, -1.881873e-001, 3.409914e-001, 5.889769e-003
17282, -1.877178e-001, 3.401100e-001, 5.889770e-003
17283, -1.872483e-001, 3.392285e-001, 5.889770e-003
17284, -1.867787e-001, 3.383470e-001, 5.889771e-003
17285, -1.863092e-001, 3.374656e-001, 5.889771e-003
17286, -1.858397e-001, 3.365841e-001, 5.889772e-003
17287, -1.853701e-001, 3.357026e-001, 5.889772e-003
17288, -1.849006e-001, 3.348212e-001, 5.889773e-003
17289, -1.844311e-001, 3.339397e-001, 5.889773e-003
17290, -1.839616e-001, 3.330582e-001, 5.889774e-003
17291, -1.834920e-001, 3.321768e-001, 5.889775e-003
17292, -1.830225e-001, 3.312953e-001, 5.889775e-003
17293, -1.825530e-001, 3.304138e-001, 5.889776e-003
17294, -1.820835e-001, 3.295324e-001, 5.889776e-003
17295, -1.816139e-001, 3.286509e-001, 5.889777e-003
17296, -1.811444e-001, 3.277694e-001, 5.889778e-003
17297, -1.806749e-001, 3.268880e-001, 5.889778e-003
17298, -1.802054e-001, 3.260065e-001, 5.889779e-003
17299, -1.797358e-001, 3.251251e-001, 5.889780e-003
17300, -1.792663e-001, 3.242436e-001, 5.889780e-003
17301, -1.787968e-001, 3.233621e-001, 5.889781e-003
17302, -1.783273e-001, 3.224807e-001, 5.889782e-003
17303, -1.778577e-001, 3.215992e-001, 5.889783e-003
17304, -1.773882e-001, 3.207177e-001, 5.889783e-003
17305, -1.769187e-001, 3.198363e-001, 5.889784e-003
17306, -1.764491e-001, 3.189548e-001, 5.889785e-003
17307, -1.759796e-001, 3.180733e-001, 5.889786e-003
17308, -1.755101e-001, 3.171919e-001, 5.889786e-003
17309, -1.750406e-001, 3.163104e-001, 5.889787e-003
17310, -1.745710e-001, 3.154290e-001, 5.889788e-003
17311, -1.741015e-001, 3.145475e-001, 5.889789e-003
17312, -1.736320e-001, 3.136660e-001, 5.889790e-003
17313, -1.731625e-001, 3.127846e-001, 5.889791e-003
17314, -1.726929e-001, 3.119031e-001, 5.889792e-003
17315, -1.722234e-001, 3.110216e-001, 5.889793e-003
17316, -1.717539e-001, 3.101402e-001, 5.889793e-003
17317, -1.712844e-001, 3.092587e-001, 5.889794e-003
17318, -1.708148e-001, 3.083773e-001, 5.889795e-003
17319, -1.703453e-001, 3.074958e-001, 5.889796e-003
17320, -1.698758e-001, 3.066143e-001, 5.889797e-003
17321, -1.694063e-001, 3.057329e-001, 5.889798e-003
17322, -1.689367e-001, 3.048514e-001, 5.889799e-003
17323, -1.684672e-001, 3.039700e-001, 5.889801e-003
17324, -1.679977e-001, 3.030885e-001, 5.889802e-003
17325, -1.675282e-001, 3.022070e-001, 5.889803e-003
17326, -1.670586e-001, 3.013256e-001, 5.889804e-003
17327, -1.665891e-001, 3.004441e-001, 5.889805e-003
17328, -1.661196e-001, 2.995627e-001, 5.889806e-003
17329, -1.656501e-001, 2.986812e-001, 5.889807e-003
17330, -1.651805e-001, 2.977997e-001, 5.889808e-003
17331, -1.647110e-001, 2.969183e-001, 5.889810e-003
17332, -1.642415e-001, 2.960368e-001, 5.889811e-003
17333, -1.637720e-001, 2.951554e-001, 5.889812e-003
17334, -1.633024e-001, 2.942739e-001, 5.889813e-003
17335, -1.628329e-001, 2.933924e-001, 5.889815e-003
17336, -1.623634e-001, 2.925110e-001, 5.889816e-003
17337, -1.618939e-001, 2.916295e-001, 5.889817e-003
17338, -1.614243e-001, 2.907481e-001, 5.889818e-003
17339, -1.609548e-001, 2.898666e-001, 5.889820e-003
17340, -1.604853e-001, 2.889851e-001, 5.889821e-003
17341, -1.600158e-001, 2.881037e-001, 5.889823e-003
17342, -1.595462e-001, 2.872222e-001, 5.889824e-003
17343, -1.590767e-001, 2.863408e-001, 5.889825e-003
17344, -1.586072e-001, 2.854593e-001, 5.889827e-003
17345, -1.581377e-001, 2.845779e-001, 5.889828e-003
17346, -1.576681e-001, 2.836964e-001, 5.889830e-003
17347, -1.571986e-001, 2.828149e-001, 5.889831e-003
17348, -1.567291e-001, 2.819335e-001, 5.889833e-003
17349, -1.562596e-001, 2.810520e-001, 5.889834e-003
17350, -1.557900e-001, 2.801706e-001, 5.889836e-003
17351, -1.553205e-001, 2.792891e-001, 5.889838e-003
17352, -1.548510e-001, 2.784077e-001, 5.889839e-003
17353, -1.543815e-001, 2.775262e-001, 5.889841e-003
17354, -1.539120e-001, 2.766447e-001, 5.889843e-003
17355, -1.534424e-001, 2.757633e-001, 5.889844e-003
17356, -1.529729e-001, 2.748818e-001, 5.889846e-003
17357, -1.525034e-001, 2.740004e-001, 5.889848e-003
17358, -1.520339e-001, 2.731189e-001, 5.889850e-003
17359, -1.515643e-001, 2.722375e-001, 5.889853e-003
17360, -1.510948e-001, 2.713560e-001, 5.889855e-003
17361, -1.506252e-001, 2.704744e-001, 5.889856e-003
17362, -1.501557e-001, 2.695930e-001, 5.889860e-003
17363, -1.496862e-001, 2.687116e-001, 5.889865e-003
17364, -1.492168e-001, 2.678303e-001, 5.889872e-003
17365, -1.487473e-001, 2.669489e-001, 5.889878e-003
17366, -1.482777e-001, 2.660674e-001, 5.889877e-003
17367, -1.478082e-001, 2.651859e-001, 5.889879e-003
17368, -1.473387e-001, 2.643045e-001, 5.889885e-003
17369, -1.468689e-001, 2.634228e-001, 5.889930e-003
17370, -1.463981e-001, 2.625425e-001, 5.890991e-003
17371, -1.459244e-001, 2.616711e-001, 5.896421e-003
17372, -1.454470e-001, 2.608233e-001, 5.910942e-003
17373, -1.449697e-001, 2.600083e-001, 5.934909e-003
17374, -1.445106e-001, 2.591913e-001, 5.948064e-003
17375, -1.324053e-001, 2.523413e-001, 5.896065e-003
17376, -2.165241e-001, 3.960552e-001, 6.368349e-003
17377, -2.169936e-001, 3.969365e-001, 6.368320e-003
17378, -1.339370e-001, 2.511125e-001, 6.752871e-003
17379, -1.348056e-001, 2.523095e-001, 6.805247e-003
17380, -1.360575e-001, 2.530510e-001, 6.944037e-003
17381, -1.367382e-001, 2.539182e-001, 6.965884e-003
17382, -1.376245e-001, 2.549651e-001, 6.988552e-003
17383, -1.386880e-001, 2.558742e-001, 6.999119e-003
17384, -1.396921e-001, 2.567806e-001, 6.976663e-003
17385, -1.407541e-001, 2.576948e-001, 6.916390e-003
17386, -1.419593e-001, 2.585631e-001, 6.781793e-003
17387, -1.433882e-001, 2.593615e-001, 6.491221e-003
17388, -1.313009e-001, 2.484943e-001, 6.353001e-003
17389, -1.342912e-001, 2.537854e-001, 6.421001e-003
17390, -1.337797e-001, 2.527996e-001, 6.426209e-003
17391, -1.373947e-001, 2.600013e-001, 6.338358e-003
17392, -1.368439e-001, 2.591386e-001, 6.299974e-003
17393, -1.357782e-001, 2.568596e-001, 6.361699e-003
17394, -1.354330e-001, 2.558592e-001, 6.435148e-003
17395, -2.179325e-001, 3.986985e-001, 6.368191e-003
17396, -2.184019e-001, 3.995792e-001, 6.368062e-003
17397, -2.167728e-001, 4.027024e-001, 7.000000e-003
17398, -2.158928e-001, 4.031684e-001, 6.928857e-003
17399, -1.328280e-001, 2.481121e-001, 6.856149e-003
17400, -1.329870e-001, 2.491019e-001, 6.781121e-003
17401, -1.319526e-001, 2.480996e-001, 6.652373e-003
17402, -2.176526e-001, 4.022363e-001, 6.928784e-003
17403, -2.160546e-001, 3.951737e-001, 6.368353e-003
17404, -2.193409e-001, 4.013407e-001, 6.367789e-003
17405, -2.185145e-001, 4.017793e-001, 6.716625e-003
17406, -2.151154e-001, 3.934106e-001, 6.368352e-003
17407, -2.155849e-001, 3.942918e-001, 6.368334e-003
17408, -1.358764e-001, 2.576359e-001, 6.226433e-003
17409, -2.150307e-001, 4.036250e-001, 6.716769e-003
17410, -1.331431e-001, 2.518422e-001, 6.376798e-003
17411, -1.325064e-001, 2.511127e-001, 6.273013e-003
17412, -1.363070e-001, 2.583498e-001, 6.249048e-003
17413, -1.383618e-001, 2.617670e-001, 6.349291e-003
17414, -1.378927e-001, 2.608881e-001, 6.348941e-003
17415, -1.398013e-001, 2.643886e-001, 6.366826e-003
17416, -1.393256e-001, 2.635128e-001, 6.363115e-003
17417, -1.402731e-001, 2.652702e-001, 6.367711e-003
17418, -1.407429e-001, 2.661505e-001, 6.368057e-003
17419, -1.412129e-001, 2.670322e-001, 6.368209e-003
17420, -1.416837e-001, 2.679157e-001, 6.368268e-003
17421, -1.421546e-001, 2.687997e-001, 6.368291e-003
17422, -1.426257e-001, 2.696842e-001, 6.368288e-003
17423, -1.430965e-001, 2.705680e-001, 6.368288e-003
17424, -1.435674e-001, 2.714520e-001, 6.368288e-003
17425, -1.440381e-001, 2.723357e-001, 6.368296e-003
17426, -1.445089e-001, 2.732195e-001, 6.368309e-003
17427, -1.449798e-001, 2.741035e-001, 6.368319e-003
17428, -1.454508e-001, 2.749876e-001, 6.368325e-003
17429, -1.459218e-001, 2.758718e-001, 6.368329e-003
17430, -1.463927e-001, 2.767560e-001, 6.368331e-003
17431, -1.468637e-001, 2.776401e-001, 6.368331e-003
17432, -1.473346e-001, 2.785242e-001, 6.368332e-003
17433, -1.478055e-001, 2.794082e-001, 6.368332e-003
17434, -1.482764e-001, 2.802923e-001, 6.368332e-003
17435, -1.487473e-001, 2.811764e-001, 6.368332e-003
17436, -1.492182e-001, 2.820604e-001, 6.368332e-003
17437, -1.496891e-001, 2.829445e-001, 6.368332e-003
17438, -1.501600e-001, 2.838285e-001, 6.368333e-003
17439, -1.506309e-001, 2.847126e-001, 6.368333e-003
17440, -1.511019e-001, 2.855967e-001, 6.368333e-003
17441, -1.515728e-001, 2.864807e-001, 6.368333e-003
17442, -1.520437e-001, 2.873648e-001, 6.368333e-003
17443, -1.525146e-001, 2.882488e-001, 6.368333e-003
17444, -1.529855e-001, 2.891329e-001, 6.368333e-003
17445, -1.534564e-001, 2.900170e-001, 6.368333e-003
17446, -1.539273e-001, 2.909010e-001, 6.368333e-003
17447, -1.543982e-001, 2.917851e-001, 6.368333e-003
17448, -1.548691e-001, 2.926691e-001, 6.368333e-003
17449, -1.553400e-001, 2.935532e-001, 6.368333e-003
17450, -1.558109e-001, 2.944373e-001, 6.368333e-003
17451, -1.562818e-001, 2.953213e-001, 6.368333e-003
17452, -1.567528e-001, 2.962054e-001, 6.368333e-003
17453, -1.572237e-001, 2.970894e-001, 6.368333e-003
17454, -1.576946e-001, 2.979735e-001, 6.368333e-003
17455, -1.581655e-001, 2.988576e-001, 6.368333e-003
17456, -1.586364e-001, 2.997416e-001, 6.368333e-003
17457, -1.591073e-001, 3.006257e-001, 6.368333e-003
17458, -1.595782e-001, 3.015097e-001, 6.368333e-003
17459, -1.600491e-001, 3.023938e-001, 6.368334e-003
17460, -1.605200e-001, 3.032779e-001, 6.368334e-003
17461, -1.609909e-001, 3.041619e-001, 6.368334e-003
17462, -1.614618e-001, 3.050460e-001, 6.368334e-003
17463, -1.619327e-001, 3.059300e-001, 6.368334e-003
17464, -1.624036e-001, 3.068141e-001, 6.368334e-003
17465, -1.628746e-001, 3.076982e-001, 6.368334e-003
17466, -1.633455e-001, 3.085822e-001, 6.368334e-003
17467, -1.638164e-001, 3.094663e-001, 6.368334e-003
17468, -1.642873e-001, 3.103503e-001, 6.368334e-003
17469, -1.647582e-001, 3.112344e-001, 6.368334e-003
17470, -1.652291e-001, 3.121185e-001, 6.368334e-003
17471, -1.657000e-001, 3.130025e-001, 6.368334e-003
17472, -1.661709e-001, 3.138866e-001, 6.368334e-003
17473, -1.666418e-001, 3.147706e-001, 6.368334e-003
17474, -1.671127e-001, 3.156547e-001, 6.368334e-003
17475, -1.675836e-001, 3.165388e-001, 6.368334e-003
17476, -1.680545e-001, 3.174228e-001, 6.368334e-003
17477, -1.685254e-001, 3.183069e-001, 6.368335e-003
17478, -1.689964e-001, 3.191909e-001, 6.368335e-003
