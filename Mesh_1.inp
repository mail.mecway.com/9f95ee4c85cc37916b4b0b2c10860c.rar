13633, -1.911067e-001, 2.145515e-001, 1.951094e-003
13634, -1.901394e-001, 2.147846e-001, 1.951091e-003
13635, -1.891721e-001, 2.150176e-001, 1.951083e-003
13636, -1.882048e-001, 2.152506e-001, 1.951073e-003
13637, -1.872374e-001, 2.154836e-001, 1.951062e-003
13638, -1.862701e-001, 2.157167e-001, 1.951051e-003
13639, -1.853028e-001, 2.159497e-001, 1.951040e-003
13640, -1.843355e-001, 2.161827e-001, 1.951029e-003
13641, -1.833682e-001, 2.164157e-001, 1.951018e-003
13642, -1.824009e-001, 2.166488e-001, 1.951007e-003
13643, -1.814336e-001, 2.168818e-001, 1.950996e-003
13644, -1.804663e-001, 2.171148e-001, 1.950985e-003
13645, -1.794989e-001, 2.173478e-001, 1.950974e-003
13646, -1.785316e-001, 2.175809e-001, 1.950962e-003
13647, -1.775643e-001, 2.178139e-001, 1.950951e-003
13648, -1.765970e-001, 2.180469e-001, 1.950940e-003
13649, -1.756297e-001, 2.182799e-001, 1.950928e-003
13650, -1.746624e-001, 2.185130e-001, 1.950917e-003
13651, -1.736951e-001, 2.187460e-001, 1.950905e-003
13652, -1.727278e-001, 2.189790e-001, 1.950894e-003
13653, -1.717605e-001, 2.192120e-001, 1.950882e-003
13654, -1.707932e-001, 2.194451e-001, 1.950870e-003
13655, -1.698259e-001, 2.196781e-001, 1.950859e-003
13656, -1.688586e-001, 2.199111e-001, 1.950847e-003
13657, -1.678913e-001, 2.201441e-001, 1.950835e-003
13658, -1.669239e-001, 2.203771e-001, 1.950823e-003
13659, -1.659566e-001, 2.206102e-001, 1.950811e-003
13660, -1.649893e-001, 2.208432e-001, 1.950800e-003
13661, -1.640220e-001, 2.210762e-001, 1.950788e-003
13662, -1.630547e-001, 2.213092e-001, 1.950776e-003
13663, -1.620874e-001, 2.215423e-001, 1.950764e-003
13664, -1.611201e-001, 2.217753e-001, 1.950752e-003
13665, -1.601528e-001, 2.220083e-001, 1.950739e-003
13666, -1.591855e-001, 2.222413e-001, 1.950727e-003
13667, -1.582182e-001, 2.224743e-001, 1.950715e-003
13668, -1.572509e-001, 2.227074e-001, 1.950704e-003
13669, -1.562836e-001, 2.229404e-001, 1.950693e-003
13670, -1.553163e-001, 2.231734e-001, 1.950685e-003
13671, -1.543490e-001, 2.234064e-001, 1.950690e-003
13672, -1.533817e-001, 2.236395e-001, 1.950736e-003
13673, -1.524144e-001, 2.238725e-001, 1.950744e-003
13674, -1.514471e-001, 2.241056e-001, 1.950731e-003
13675, -1.504798e-001, 2.243386e-001, 1.950740e-003
13676, -1.495125e-001, 2.245716e-001, 1.950717e-003
13677, -1.485452e-001, 2.248046e-001, 1.950670e-003
13678, -1.475780e-001, 2.250375e-001, 1.950568e-003
13679, -1.466107e-001, 2.252705e-001, 1.950525e-003
13680, -1.456434e-001, 2.255036e-001, 1.950565e-003
13681, -1.446761e-001, 2.257366e-001, 1.950540e-003
13682, -1.437088e-001, 2.259696e-001, 1.950520e-003
13683, -1.427415e-001, 2.262027e-001, 1.950552e-003
13684, -1.417742e-001, 2.264357e-001, 1.950482e-003
13685, -1.408062e-001, 2.266693e-001, 1.951209e-003
13686, -1.398354e-001, 2.269032e-001, 1.951290e-003
13687, -1.388636e-001, 2.271336e-001, 1.944878e-003
13688, -1.379030e-001, 2.273565e-001, 1.929920e-003
13689, -1.369798e-001, 2.275713e-001, 1.916384e-003
13690, -1.361457e-001, 2.277710e-001, 1.914239e-003
13691, -1.354791e-001, 2.279591e-001, 1.962559e-003
13692, -1.377739e-001, 2.346250e-001, 1.876628e-003
13693, -1.376215e-001, 2.340413e-001, 2.723820e-003
13694, -1.373723e-001, 2.334040e-001, 3.306280e-003
13695, -1.367890e-001, 2.327178e-001, 3.728848e-003
13696, -1.363027e-001, 2.320709e-001, 3.937421e-003
13697, -1.358928e-001, 2.314228e-001, 3.999943e-003
13698, -1.355331e-001, 2.307882e-001, 3.934213e-003
13699, -1.352565e-001, 2.301948e-001, 3.760207e-003
13700, -1.353142e-001, 2.295810e-001, 3.494000e-003
13701, -1.353334e-001, 2.289345e-001, 3.064009e-003
13702, -1.353736e-001, 2.283669e-001, 2.510931e-003
13703, -1.393129e-001, 2.336090e-001, 2.749580e-003
13704, -1.384433e-001, 2.338486e-001, 2.718243e-003
13705, -1.402520e-001, 2.333671e-001, 2.765565e-003
13706, -1.431545e-001, 2.326461e-001, 2.787526e-003
13707, -1.421839e-001, 2.328821e-001, 2.785353e-003
13708, -1.441280e-001, 2.324107e-001, 2.788409e-003
13709, -1.451007e-001, 2.321763e-001, 2.788507e-003
13710, -1.460734e-001, 2.319419e-001, 2.788526e-003
13711, -1.470459e-001, 2.317077e-001, 2.788475e-003
13712, -1.480185e-001, 2.314729e-001, 2.788945e-003
13713, -1.489908e-001, 2.312385e-001, 2.789130e-003
13714, -1.499629e-001, 2.310047e-001, 2.788691e-003
13715, -1.509351e-001, 2.307707e-001, 2.788507e-003
13716, -1.519073e-001, 2.305365e-001, 2.788508e-003
13717, -1.528796e-001, 2.303023e-001, 2.788533e-003
13718, -1.538519e-001, 2.300680e-001, 2.788521e-003
13719, -1.548242e-001, 2.298337e-001, 2.788603e-003
13720, -1.557965e-001, 2.295994e-001, 2.788737e-003
13721, -1.567688e-001, 2.293650e-001, 2.788862e-003
13722, -1.577410e-001, 2.291307e-001, 2.788951e-003
13723, -1.587133e-001, 2.288964e-001, 2.789006e-003
13724, -1.596856e-001, 2.286621e-001, 2.789037e-003
13725, -1.606579e-001, 2.284279e-001, 2.789054e-003
13726, -1.616301e-001, 2.281937e-001, 2.789064e-003
13727, -1.626024e-001, 2.279594e-001, 2.789071e-003
13728, -1.635746e-001, 2.277252e-001, 2.789076e-003
13729, -1.645469e-001, 2.274910e-001, 2.789080e-003
13730, -1.655192e-001, 2.272568e-001, 2.789084e-003
13731, -1.664914e-001, 2.270225e-001, 2.789088e-003
13732, -1.674637e-001, 2.267883e-001, 2.789092e-003
13733, -1.684360e-001, 2.265541e-001, 2.789095e-003
13734, -1.694082e-001, 2.263198e-001, 2.789099e-003
13735, -1.703805e-001, 2.260856e-001, 2.789103e-003
13736, -1.713528e-001, 2.258514e-001, 2.789106e-003
13737, -1.723250e-001, 2.256172e-001, 2.789110e-003
13738, -1.732973e-001, 2.253829e-001, 2.789114e-003
13739, -1.742695e-001, 2.251487e-001, 2.789118e-003
13740, -1.752418e-001, 2.249145e-001, 2.789121e-003
13741, -1.762141e-001, 2.246803e-001, 2.789125e-003
13742, -1.771863e-001, 2.244460e-001, 2.789128e-003
13743, -1.781586e-001, 2.242118e-001, 2.789132e-003
13744, -1.791309e-001, 2.239776e-001, 2.789136e-003
13745, -1.801031e-001, 2.237433e-001, 2.789139e-003
13746, -1.810754e-001, 2.235091e-001, 2.789143e-003
13747, -1.820476e-001, 2.232749e-001, 2.789147e-003
13748, -1.830199e-001, 2.230407e-001, 2.789150e-003
13749, -1.839922e-001, 2.228064e-001, 2.789154e-003
13750, -1.849644e-001, 2.225722e-001, 2.789157e-003
13751, -1.859367e-001, 2.223380e-001, 2.789161e-003
13752, -1.869089e-001, 2.221038e-001, 2.789164e-003
13753, -1.878812e-001, 2.218695e-001, 2.789168e-003
13754, -1.888535e-001, 2.216353e-001, 2.789171e-003
13755, -1.898257e-001, 2.214011e-001, 2.789174e-003
13756, -1.907980e-001, 2.211669e-001, 2.789178e-003
13757, -1.917703e-001, 2.209326e-001, 2.789182e-003
13758, -1.927425e-001, 2.206984e-001, 2.789185e-003
13759, -1.937148e-001, 2.204642e-001, 2.789189e-003
13760, -1.946870e-001, 2.202299e-001, 2.789193e-003
13761, -1.956593e-001, 2.199957e-001, 2.789199e-003
13762, -1.966315e-001, 2.197615e-001, 2.789209e-003
13763, -1.976038e-001, 2.195272e-001, 2.789233e-003
13764, -1.985768e-001, 2.192922e-001, 2.789893e-003
13765, -1.995522e-001, 2.190536e-001, 2.793476e-003
13766, -2.005329e-001, 2.188119e-001, 2.798887e-003
13767, -2.015171e-001, 2.185754e-001, 2.798275e-003
13768, -2.024897e-001, 2.183544e-001, 2.785026e-003
13769, -2.034573e-001, 2.181325e-001, 2.773731e-003
13770, -2.044237e-001, 2.179065e-001, 2.766859e-003
13771, -2.053917e-001, 2.176766e-001, 2.763544e-003
13772, -2.063625e-001, 2.174445e-001, 2.761734e-003
13773, -2.073379e-001, 2.172149e-001, 2.756267e-003
13774, -2.083293e-001, 2.169925e-001, 2.739273e-003
13775, -2.093546e-001, 2.167805e-001, 2.702715e-003
13776, -2.104011e-001, 2.165960e-001, 2.629121e-003
13777, -2.113297e-001, 2.164801e-001, 2.503868e-003
13778, -2.120979e-001, 2.162650e-001, 2.539808e-003
13779, -2.076417e-001, 2.111986e-001, 2.776941e-003
13780, -2.085434e-001, 2.110262e-001, 2.821424e-003
13781, -2.067043e-001, 2.113984e-001, 2.750521e-003
13782, -2.108481e-001, 2.105796e-001, 2.923753e-003
13783, -2.112127e-001, 2.113555e-001, 3.525243e-003
13784, -2.115163e-001, 2.120910e-001, 3.844649e-003
13785, -2.118105e-001, 2.127879e-001, 3.983991e-003
13786, -2.120362e-001, 2.134473e-001, 3.985829e-003
13787, -2.120364e-001, 2.141348e-001, 3.871744e-003
13788, -2.119391e-001, 2.148328e-001, 3.639018e-003
13789, -2.117732e-001, 2.154905e-001, 3.299554e-003
13790, -2.101370e-001, 2.111448e-001, 3.239177e-003
13791, -2.093934e-001, 2.109755e-001, 2.964404e-003
13792, -2.057516e-001, 2.116148e-001, 2.736936e-003
13793, -2.047904e-001, 2.118412e-001, 2.731627e-003
13794, -2.038252e-001, 2.120727e-001, 2.730584e-003
13795, -2.028594e-001, 2.123053e-001, 2.730446e-003
13796, -2.018948e-001, 2.125407e-001, 2.733634e-003
13797, -2.009326e-001, 2.127804e-001, 2.741753e-003
13798, -1.999702e-001, 2.130243e-001, 2.754200e-003
13799, -1.990066e-001, 2.132679e-001, 2.765830e-003
13800, -1.980414e-001, 2.135087e-001, 2.774226e-003
13801, -1.970751e-001, 2.137465e-001, 2.779292e-003
13802, -1.961082e-001, 2.139820e-001, 2.781945e-003
13803, -1.951409e-001, 2.142163e-001, 2.783209e-003
13804, -1.941733e-001, 2.144500e-001, 2.783770e-003
13805, -1.932056e-001, 2.146833e-001, 2.784001e-003
13806, -1.922379e-001, 2.149166e-001, 2.784087e-003
13807, -1.912702e-001, 2.151497e-001, 2.784112e-003
13808, -1.903024e-001, 2.153829e-001, 2.784112e-003
13809, -1.893347e-001, 2.156160e-001, 2.784101e-003
13810, -1.883669e-001, 2.158491e-001, 2.784086e-003
13811, -1.873991e-001, 2.160822e-001, 2.784069e-003
13812, -1.864314e-001, 2.163154e-001, 2.784051e-003
13813, -1.854636e-001, 2.165485e-001, 2.784033e-003
13814, -1.844958e-001, 2.167816e-001, 2.784015e-003
13815, -1.835281e-001, 2.170147e-001, 2.783998e-003
13816, -1.825603e-001, 2.172478e-001, 2.783980e-003
13817, -1.815926e-001, 2.174810e-001, 2.783962e-003
13818, -1.806248e-001, 2.177141e-001, 2.783944e-003
13819, -1.796570e-001, 2.179472e-001, 2.783925e-003
13820, -1.786893e-001, 2.181803e-001, 2.783907e-003
13821, -1.777215e-001, 2.184134e-001, 2.783889e-003
13822, -1.767538e-001, 2.186466e-001, 2.783870e-003
13823, -1.757860e-001, 2.188797e-001, 2.783851e-003
13824, -1.748182e-001, 2.191128e-001, 2.783833e-003
13825, -1.738505e-001, 2.193459e-001, 2.783814e-003
13826, -1.728827e-001, 2.195790e-001, 2.783795e-003
13827, -1.719150e-001, 2.198122e-001, 2.783776e-003
13828, -1.709472e-001, 2.200453e-001, 2.783757e-003
13829, -1.699795e-001, 2.202784e-001, 2.783738e-003
13830, -1.690117e-001, 2.205115e-001, 2.783719e-003
13831, -1.680440e-001, 2.207446e-001, 2.783699e-003
13832, -1.670762e-001, 2.209777e-001, 2.783680e-003
13833, -1.661085e-001, 2.212109e-001, 2.783660e-003
13834, -1.651407e-001, 2.214440e-001, 2.783641e-003
13835, -1.641730e-001, 2.216771e-001, 2.783621e-003
13836, -1.632052e-001, 2.219102e-001, 2.783601e-003
13837, -1.622375e-001, 2.221433e-001, 2.783582e-003
13838, -1.612697e-001, 2.223764e-001, 2.783562e-003
13839, -1.603020e-001, 2.226096e-001, 2.783542e-003
13840, -1.593342e-001, 2.228427e-001, 2.783522e-003
13841, -1.583665e-001, 2.230758e-001, 2.783503e-003
13842, -1.573987e-001, 2.233089e-001, 2.783487e-003
13843, -1.564310e-001, 2.235420e-001, 2.783478e-003
13844, -1.554632e-001, 2.237752e-001, 2.783494e-003
13845, -1.544955e-001, 2.240084e-001, 2.783594e-003
13846, -1.535277e-001, 2.242417e-001, 2.783691e-003
13847, -1.525599e-001, 2.244748e-001, 2.783714e-003
13848, -1.515922e-001, 2.247080e-001, 2.783704e-003
13849, -1.506244e-001, 2.249411e-001, 2.783708e-003
13850, -1.496567e-001, 2.251741e-001, 2.783631e-003
13851, -1.486892e-001, 2.254070e-001, 2.783400e-003
13852, -1.477215e-001, 2.256399e-001, 2.783162e-003
13853, -1.467538e-001, 2.258730e-001, 2.783144e-003
13854, -1.457861e-001, 2.261062e-001, 2.783192e-003
13855, -1.448183e-001, 2.263392e-001, 2.783136e-003
13856, -1.438506e-001, 2.265724e-001, 2.783143e-003
13857, -1.428828e-001, 2.268055e-001, 2.783122e-003
13858, -1.419143e-001, 2.270395e-001, 2.783833e-003
13859, -1.409409e-001, 2.272755e-001, 2.785316e-003
13860, -1.399579e-001, 2.275095e-001, 2.782447e-003
13861, -1.389669e-001, 2.277302e-001, 2.764253e-003
13862, -1.379925e-001, 2.279247e-001, 2.722810e-003
13863, -1.370520e-001, 2.281028e-001, 2.671149e-003
13864, -1.361803e-001, 2.282516e-001, 2.603289e-003
13865, -1.412152e-001, 2.331232e-001, 2.777597e-003
13866, -2.113029e-001, 2.160018e-001, 2.997886e-003
13867, -1.449089e-001, 2.313877e-001, 3.431037e-003
13868, -1.439368e-001, 2.316212e-001, 3.431380e-003
13869, -1.374846e-001, 2.321181e-001, 3.865770e-003
13870, -1.369984e-001, 2.315762e-001, 3.981251e-003
13871, -1.366129e-001, 2.309809e-001, 3.990030e-003
13872, -1.362014e-001, 2.304007e-001, 3.887342e-003
13873, -1.360832e-001, 2.296540e-001, 3.622514e-003
13874, -1.361639e-001, 2.288854e-001, 3.181418e-003
13875, -1.390735e-001, 2.329160e-001, 3.356726e-003
13876, -1.382199e-001, 2.332239e-001, 3.290173e-003
13877, -1.400322e-001, 2.326236e-001, 3.394735e-003
13878, -1.458820e-001, 2.311525e-001, 3.431481e-003
13879, -1.410086e-001, 2.323543e-001, 3.415161e-003
13880, -1.429628e-001, 2.318580e-001, 3.430146e-003
13881, -1.419872e-001, 2.320995e-001, 3.426353e-003
13882, -1.468543e-001, 2.309185e-001, 3.431306e-003
13883, -1.478267e-001, 2.306830e-001, 3.432073e-003
13884, -1.487987e-001, 2.304484e-001, 3.432288e-003
13885, -1.497702e-001, 2.302160e-001, 3.431338e-003
13886, -1.507420e-001, 2.299823e-001, 3.431143e-003
13887, -1.517138e-001, 2.297482e-001, 3.431125e-003
13888, -1.526858e-001, 2.295139e-001, 3.431187e-003
13889, -1.536577e-001, 2.292798e-001, 3.431167e-003
13890, -1.546296e-001, 2.290454e-001, 3.431310e-003
13891, -1.556016e-001, 2.288109e-001, 3.431507e-003
13892, -1.565735e-001, 2.285765e-001, 3.431680e-003
13893, -1.575455e-001, 2.283421e-001, 3.431800e-003
13894, -1.585174e-001, 2.281079e-001, 3.431873e-003
13895, -1.594893e-001, 2.278737e-001, 3.431915e-003
13896, -1.604612e-001, 2.276395e-001, 3.431938e-003
13897, -1.614331e-001, 2.274053e-001, 3.431952e-003
13898, -1.624050e-001, 2.271712e-001, 3.431960e-003
13899, -1.633768e-001, 2.269370e-001, 3.431966e-003
13900, -1.643487e-001, 2.267029e-001, 3.431972e-003
13901, -1.653206e-001, 2.264687e-001, 3.431976e-003
13902, -1.662925e-001, 2.262346e-001, 3.431981e-003
13903, -1.672644e-001, 2.260005e-001, 3.431986e-003
13904, -1.682363e-001, 2.257663e-001, 3.431990e-003
13905, -1.692082e-001, 2.255322e-001, 3.431995e-003
13906, -1.701801e-001, 2.252980e-001, 3.431999e-003
13907, -1.711520e-001, 2.250639e-001, 3.432004e-003
13908, -1.721239e-001, 2.248298e-001, 3.432008e-003
13909, -1.730958e-001, 2.245956e-001, 3.432012e-003
13910, -1.740676e-001, 2.243615e-001, 3.432017e-003
13911, -1.750395e-001, 2.241273e-001, 3.432021e-003
13912, -1.760114e-001, 2.238932e-001, 3.432026e-003
13913, -1.769833e-001, 2.236590e-001, 3.432030e-003
13914, -1.779552e-001, 2.234249e-001, 3.432034e-003
13915, -1.789271e-001, 2.231908e-001, 3.432039e-003
13916, -1.798990e-001, 2.229566e-001, 3.432043e-003
13917, -1.808709e-001, 2.227225e-001, 3.432048e-003
13918, -1.818427e-001, 2.224883e-001, 3.432052e-003
13919, -1.828146e-001, 2.222542e-001, 3.432056e-003
13920, -1.837865e-001, 2.220201e-001, 3.432060e-003
13921, -1.847584e-001, 2.217859e-001, 3.432065e-003
13922, -1.857303e-001, 2.215518e-001, 3.432069e-003
13923, -1.867022e-001, 2.213176e-001, 3.432073e-003
13924, -1.876741e-001, 2.210835e-001, 3.432077e-003
13925, -1.886460e-001, 2.208494e-001, 3.432081e-003
13926, -1.896178e-001, 2.206152e-001, 3.432085e-003
13927, -1.905897e-001, 2.203811e-001, 3.432090e-003
13928, -1.915616e-001, 2.201469e-001, 3.432094e-003
13929, -1.925335e-001, 2.199128e-001, 3.432099e-003
13930, -1.935054e-001, 2.196787e-001, 3.432104e-003
13931, -1.944773e-001, 2.194445e-001, 3.432113e-003
13932, -1.954491e-001, 2.192104e-001, 3.432130e-003
13933, -1.964210e-001, 2.189762e-001, 3.432172e-003
13934, -1.973932e-001, 2.187413e-001, 3.432542e-003
13935, -1.983673e-001, 2.185021e-001, 3.435185e-003
13936, -1.993481e-001, 2.182544e-001, 3.441770e-003
13937, -2.003441e-001, 2.180022e-001, 3.448792e-003
13938, -2.013587e-001, 2.177668e-001, 3.443674e-003
13939, -2.023253e-001, 2.175954e-001, 3.407605e-003
13940, -2.032826e-001, 2.173981e-001, 3.387504e-003
13941, -2.042382e-001, 2.171826e-001, 3.378449e-003
13942, -2.051996e-001, 2.169567e-001, 3.374938e-003
13943, -2.061678e-001, 2.167265e-001, 3.373056e-003
13944, -2.071484e-001, 2.164976e-001, 3.368493e-003
13945, -2.081635e-001, 2.162698e-001, 3.358010e-003
13946, -2.092506e-001, 2.160377e-001, 3.339142e-003
13947, -2.104695e-001, 2.158149e-001, 3.292632e-003
13948, -2.102773e-001, 2.119064e-001, 3.677448e-003
13949, -2.077929e-001, 2.118782e-001, 3.351886e-003
13950, -2.086129e-001, 2.116248e-001, 3.315887e-003
13951, -2.068825e-001, 2.120946e-001, 3.350000e-003
13952, -1.380301e-001, 2.325988e-001, 3.656123e-003
13953, -2.106318e-001, 2.125801e-001, 3.911758e-003
13954, -2.110797e-001, 2.131646e-001, 3.996699e-003
13955, -2.114579e-001, 2.135751e-001, 3.986762e-003
13956, -2.112796e-001, 2.141046e-001, 3.919549e-003
13957, -2.111051e-001, 2.147760e-001, 3.743235e-003
13958, -2.111302e-001, 2.153551e-001, 3.476163e-003
13959, -2.040212e-001, 2.127789e-001, 3.346845e-003
13960, -2.049841e-001, 2.125430e-001, 3.344309e-003
13961, -2.030590e-001, 2.130128e-001, 3.348187e-003
13962, -2.021008e-001, 2.132553e-001, 3.355585e-003
13963, -2.011477e-001, 2.135096e-001, 3.371005e-003
13964, -2.001909e-001, 2.137780e-001, 3.394255e-003
13965, -1.992286e-001, 2.140424e-001, 3.413838e-003
13966, -1.982629e-001, 2.142976e-001, 3.427130e-003
13967, -1.972960e-001, 2.145439e-001, 3.434904e-003
13968, -1.963284e-001, 2.147839e-001, 3.438881e-003
13969, -1.953604e-001, 2.150202e-001, 3.440706e-003
13970, -1.943922e-001, 2.152548e-001, 3.441496e-003
13971, -1.934238e-001, 2.154887e-001, 3.441821e-003
13972, -1.924554e-001, 2.157222e-001, 3.441946e-003
13973, -1.914869e-001, 2.159556e-001, 3.441989e-003
13974, -1.905184e-001, 2.161889e-001, 3.441997e-003
13975, -1.895498e-001, 2.164223e-001, 3.441992e-003
13976, -1.885813e-001, 2.166556e-001, 3.441982e-003
13977, -1.876128e-001, 2.168889e-001, 3.441968e-003
13978, -1.866443e-001, 2.171222e-001, 3.441954e-003
13979, -1.856758e-001, 2.173555e-001, 3.441940e-003
13980, -1.847072e-001, 2.175888e-001, 3.441925e-003
13981, -1.837387e-001, 2.178221e-001, 3.441911e-003
13982, -1.827702e-001, 2.180554e-001, 3.441897e-003
13983, -1.818017e-001, 2.182886e-001, 3.441882e-003
13984, -1.808332e-001, 2.185219e-001, 3.441868e-003
13985, -1.798646e-001, 2.187552e-001, 3.441853e-003
13986, -1.788961e-001, 2.189885e-001, 3.441838e-003
13987, -1.779276e-001, 2.192218e-001, 3.441823e-003
13988, -1.769591e-001, 2.194551e-001, 3.441808e-003
13989, -1.759906e-001, 2.196884e-001, 3.441793e-003
13990, -1.750221e-001, 2.199217e-001, 3.441778e-003
13991, -1.740535e-001, 2.201550e-001, 3.441763e-003
13992, -1.730850e-001, 2.203883e-001, 3.441747e-003
13993, -1.721165e-001, 2.206216e-001, 3.441732e-003
13994, -1.711480e-001, 2.208549e-001, 3.441717e-003
13995, -1.701795e-001, 2.210882e-001, 3.441701e-003
13996, -1.692110e-001, 2.213215e-001, 3.441685e-003
13997, -1.682425e-001, 2.215548e-001, 3.441669e-003
13998, -1.672740e-001, 2.217881e-001, 3.441653e-003
13999, -1.663055e-001, 2.220213e-001, 3.441638e-003
14000, -1.653370e-001, 2.222546e-001, 3.441622e-003
14001, -1.643684e-001, 2.224879e-001, 3.441606e-003
14002, -1.633999e-001, 2.227212e-001, 3.441589e-003
14003, -1.624314e-001, 2.229545e-001, 3.441573e-003
14004, -1.614629e-001, 2.231878e-001, 3.441557e-003
14005, -1.604944e-001, 2.234211e-001, 3.441542e-003
14006, -1.595259e-001, 2.236544e-001, 3.441527e-003
14007, -1.585574e-001, 2.238877e-001, 3.441515e-003
14008, -1.575889e-001, 2.241210e-001, 3.441512e-003
14009, -1.566204e-001, 2.243543e-001, 3.441535e-003
14010, -1.556519e-001, 2.245878e-001, 3.441635e-003
14011, -1.546833e-001, 2.248215e-001, 3.441796e-003
14012, -1.537148e-001, 2.250550e-001, 3.441933e-003
14013, -1.527462e-001, 2.252885e-001, 3.441992e-003
14014, -1.517777e-001, 2.255217e-001, 3.441951e-003
14015, -1.508092e-001, 2.257551e-001, 3.441975e-003
14016, -1.498409e-001, 2.259880e-001, 3.441763e-003
14017, -1.488726e-001, 2.262206e-001, 3.441376e-003
14018, -1.479043e-001, 2.264533e-001, 3.441077e-003
14019, -1.469358e-001, 2.266866e-001, 3.441047e-003
14020, -1.459673e-001, 2.269200e-001, 3.441134e-003
14021, -1.449988e-001, 2.271532e-001, 3.441053e-003
14022, -1.440303e-001, 2.273864e-001, 3.440981e-003
14023, -1.430611e-001, 2.276206e-001, 3.441389e-003
14024, -1.420877e-001, 2.278573e-001, 3.442674e-003
14025, -1.411022e-001, 2.280965e-001, 3.443668e-003
14026, -1.400933e-001, 2.283309e-001, 3.438705e-003
14027, -1.390522e-001, 2.285395e-001, 3.413992e-003
14028, -1.380527e-001, 2.286706e-001, 3.346554e-003
14029, -1.370694e-001, 2.288018e-001, 3.276984e-003
14030, -2.059397e-001, 2.123138e-001, 3.344996e-003
14031, -2.098710e-001, 2.115599e-001, 3.460873e-003
14032, -1.373463e-001, 2.305208e-001, 3.960918e-003
14033, -1.370178e-001, 2.296635e-001, 3.720848e-003
14034, -1.466374e-001, 2.299747e-001, 3.849374e-003
14035, -1.456666e-001, 2.302054e-001, 3.850231e-003
14036, -1.397651e-001, 2.317308e-001, 3.820418e-003
14037, -1.387116e-001, 2.321187e-001, 3.777504e-003
14038, -1.407681e-001, 2.314315e-001, 3.837348e-003
14039, -1.476097e-001, 2.297370e-001, 3.850325e-003
14040, -2.061644e-001, 2.131080e-001, 3.758546e-003
14041, -2.071136e-001, 2.128720e-001, 3.755961e-003
14042, -1.427439e-001, 2.309175e-001, 3.848037e-003
14043, -1.417601e-001, 2.311640e-001, 3.845397e-003
14044, -1.437210e-001, 2.306760e-001, 3.849705e-003
14045, -2.023515e-001, 2.140665e-001, 3.772455e-003
14046, -2.032978e-001, 2.138135e-001, 3.763795e-003
14047, -1.495514e-001, 2.292729e-001, 3.849310e-003
14048, -1.485815e-001, 2.295012e-001, 3.850786e-003
14049, -1.505228e-001, 2.290386e-001, 3.849390e-003
14050, -1.514941e-001, 2.288047e-001, 3.849352e-003
14051, -1.524654e-001, 2.285703e-001, 3.849472e-003
14052, -1.534367e-001, 2.283367e-001, 3.849378e-003
14053, -1.544080e-001, 2.281022e-001, 3.849513e-003
14054, -1.553794e-001, 2.278676e-001, 3.849671e-003
14055, -1.563507e-001, 2.276331e-001, 3.849800e-003
14056, -1.573219e-001, 2.273988e-001, 3.849887e-003
14057, -1.582932e-001, 2.271647e-001, 3.849939e-003
14058, -1.592644e-001, 2.269306e-001, 3.849967e-003
14059, -1.602357e-001, 2.266966e-001, 3.849982e-003
14060, -1.612069e-001, 2.264625e-001, 3.849990e-003
14061, -1.621782e-001, 2.262286e-001, 3.849994e-003
14062, -1.631494e-001, 2.259946e-001, 3.849997e-003
14063, -1.641206e-001, 2.257606e-001, 3.849999e-003
14064, -1.650919e-001, 2.255266e-001, 3.850000e-003
14065, -1.660631e-001, 2.252926e-001, 3.850002e-003
14066, -1.670343e-001, 2.250586e-001, 3.850003e-003
14067, -1.680056e-001, 2.248247e-001, 3.850004e-003
14068, -1.689768e-001, 2.245907e-001, 3.850006e-003
14069, -1.699481e-001, 2.243567e-001, 3.850007e-003
14070, -1.709193e-001, 2.241227e-001, 3.850008e-003
14071, -1.718905e-001, 2.238887e-001, 3.850010e-003
14072, -1.728618e-001, 2.236548e-001, 3.850011e-003
14073, -1.738330e-001, 2.234208e-001, 3.850012e-003
14074, -1.748043e-001, 2.231868e-001, 3.850013e-003
14075, -1.757755e-001, 2.229528e-001, 3.850015e-003
14076, -1.767467e-001, 2.227188e-001, 3.850016e-003
14077, -1.777180e-001, 2.224848e-001, 3.850017e-003
14078, -1.786892e-001, 2.222509e-001, 3.850019e-003
14079, -1.796604e-001, 2.220169e-001, 3.850020e-003
14080, -1.806317e-001, 2.217829e-001, 3.850021e-003
14081, -1.816029e-001, 2.215489e-001, 3.850023e-003
14082, -1.825741e-001, 2.213149e-001, 3.850024e-003
14083, -1.835454e-001, 2.210810e-001, 3.850025e-003
14084, -1.845166e-001, 2.208470e-001, 3.850026e-003
14085, -1.854879e-001, 2.206130e-001, 3.850028e-003
14086, -1.864591e-001, 2.203790e-001, 3.850029e-003
14087, -1.874303e-001, 2.201450e-001, 3.850030e-003
14088, -1.884016e-001, 2.199111e-001, 3.850031e-003
14089, -1.893728e-001, 2.196771e-001, 3.850033e-003
14090, -1.903440e-001, 2.194431e-001, 3.850034e-003
14091, -1.913153e-001, 2.192091e-001, 3.850036e-003
14092, -1.922865e-001, 2.189751e-001, 3.850039e-003
14093, -1.932577e-001, 2.187411e-001, 3.850045e-003
14094, -1.942290e-001, 2.185071e-001, 3.850059e-003
14095, -1.952002e-001, 2.182730e-001, 3.850097e-003
14096, -1.961714e-001, 2.180385e-001, 3.850232e-003
14097, -1.971430e-001, 2.178012e-001, 3.851115e-003
14098, -1.981178e-001, 2.175553e-001, 3.854128e-003
14099, -1.991045e-001, 2.172956e-001, 3.859995e-003
14100, -2.001253e-001, 2.170229e-001, 3.866995e-003
14101, -2.012508e-001, 2.167482e-001, 3.867895e-003
14102, -2.021730e-001, 2.167540e-001, 3.802600e-003
14103, -2.031015e-001, 2.165834e-001, 3.785361e-003
14104, -2.040342e-001, 2.163726e-001, 3.780698e-003
14105, -2.049838e-001, 2.161475e-001, 3.779475e-003
14106, -2.059471e-001, 2.159167e-001, 3.779067e-003
14107, -2.069286e-001, 2.156826e-001, 3.778258e-003
14108, -2.079532e-001, 2.154346e-001, 3.778652e-003
14109, -2.090650e-001, 2.151470e-001, 3.785289e-003
14110, -2.101477e-001, 2.148364e-001, 3.801452e-003
14111, -2.080744e-001, 2.126138e-001, 3.746333e-003
14112, -2.092798e-001, 2.122819e-001, 3.730987e-003
14113, -2.096584e-001, 2.132722e-001, 3.980867e-003
14114, -1.381027e-001, 2.316201e-001, 3.940363e-003
14115, -2.105503e-001, 2.138314e-001, 3.983602e-003
14116, -2.092863e-001, 2.116151e-001, 3.411264e-003
14117, -1.375670e-001, 2.311503e-001, 3.998597e-003
14118, -2.042520e-001, 2.135728e-001, 3.759990e-003
14119, -2.052090e-001, 2.133353e-001, 3.757531e-003
14120, -2.004686e-001, 2.146614e-001, 3.818109e-003
14121, -2.014185e-001, 2.143414e-001, 3.789293e-003
14122, -1.995017e-001, 2.149602e-001, 3.837524e-003
14123, -1.985295e-001, 2.152360e-001, 3.849197e-003
14124, -1.975588e-001, 2.154939e-001, 3.855724e-003
14125, -1.965893e-001, 2.157396e-001, 3.858963e-003
14126, -1.956202e-001, 2.159783e-001, 3.860354e-003
14127, -1.946510e-001, 2.162139e-001, 3.860902e-003
14128, -1.936817e-001, 2.164482e-001, 3.861119e-003
14129, -1.927123e-001, 2.166821e-001, 3.861202e-003
14130, -1.917428e-001, 2.169157e-001, 3.861232e-003
14131, -1.907734e-001, 2.171493e-001, 3.861241e-003
14132, -1.898039e-001, 2.173829e-001, 3.861241e-003
14133, -1.888344e-001, 2.176164e-001, 3.861238e-003
14134, -1.878650e-001, 2.178499e-001, 3.861234e-003
14135, -1.868955e-001, 2.180835e-001, 3.861229e-003
14136, -1.859261e-001, 2.183170e-001, 3.861224e-003
14137, -1.849566e-001, 2.185505e-001, 3.861220e-003
14138, -1.839871e-001, 2.187841e-001, 3.861215e-003
14139, -1.830177e-001, 2.190176e-001, 3.861210e-003
14140, -1.820482e-001, 2.192511e-001, 3.861205e-003
14141, -1.810787e-001, 2.194847e-001, 3.861200e-003
14142, -1.801093e-001, 2.197182e-001, 3.861195e-003
14143, -1.791398e-001, 2.199517e-001, 3.861190e-003
14144, -1.781704e-001, 2.201852e-001, 3.861185e-003
14145, -1.772009e-001, 2.204188e-001, 3.861179e-003
14146, -1.762314e-001, 2.206523e-001, 3.861174e-003
14147, -1.752620e-001, 2.208858e-001, 3.861169e-003
14148, -1.742925e-001, 2.211194e-001, 3.861164e-003
14149, -1.733231e-001, 2.213529e-001, 3.861158e-003
14150, -1.723536e-001, 2.215864e-001, 3.861153e-003
14151, -1.713841e-001, 2.218199e-001, 3.861148e-003
14152, -1.704147e-001, 2.220535e-001, 3.861142e-003
14153, -1.694452e-001, 2.222870e-001, 3.861137e-003
14154, -1.684758e-001, 2.225205e-001, 3.861131e-003
14155, -1.675063e-001, 2.227540e-001, 3.861126e-003
14156, -1.665369e-001, 2.229876e-001, 3.861120e-003
14157, -1.655674e-001, 2.232211e-001, 3.861115e-003
14158, -1.645980e-001, 2.234546e-001, 3.861109e-003
14159, -1.636285e-001, 2.236881e-001, 3.861103e-003
14160, -1.626591e-001, 2.239217e-001, 3.861098e-003
14161, -1.616896e-001, 2.241552e-001, 3.861093e-003
14162, -1.607202e-001, 2.243887e-001, 3.861088e-003
14163, -1.597507e-001, 2.246223e-001, 3.861086e-003
14164, -1.587813e-001, 2.248558e-001, 3.861088e-003
14165, -1.578118e-001, 2.250894e-001, 3.861102e-003
14166, -1.568423e-001, 2.253231e-001, 3.861145e-003
14167, -1.558729e-001, 2.255570e-001, 3.861233e-003
14168, -1.549033e-001, 2.257910e-001, 3.861355e-003
14169, -1.539338e-001, 2.260251e-001, 3.861481e-003
14170, -1.529643e-001, 2.262590e-001, 3.861565e-003
14171, -1.519948e-001, 2.264921e-001, 3.861465e-003
14172, -1.510253e-001, 2.267260e-001, 3.861539e-003
14173, -1.500561e-001, 2.269587e-001, 3.861325e-003
14174, -1.490869e-001, 2.271910e-001, 3.861020e-003
14175, -1.481177e-001, 2.274234e-001, 3.860744e-003
14176, -1.471483e-001, 2.276568e-001, 3.860703e-003
14177, -1.461787e-001, 2.278910e-001, 3.860870e-003
14178, -1.452092e-001, 2.281240e-001, 3.860718e-003
14179, -1.442394e-001, 2.283574e-001, 3.860669e-003
14180, -1.432674e-001, 2.285936e-001, 3.861198e-003
14181, -1.422880e-001, 2.288330e-001, 3.862115e-003
14182, -1.412897e-001, 2.290773e-001, 3.863099e-003
14183, -1.402479e-001, 2.293259e-001, 3.862484e-003
14184, -1.390740e-001, 2.295762e-001, 3.853845e-003
14185, -1.380806e-001, 2.295349e-001, 3.767378e-003
14186, -1.446950e-001, 2.304374e-001, 3.850792e-003
14187, -1.464078e-001, 2.289362e-001, 3.999928e-003
14188, -1.454374e-001, 2.291682e-001, 3.999938e-003
14189, -2.017379e-001, 2.152033e-001, 3.983003e-003
14190, -2.026362e-001, 2.149141e-001, 3.975824e-003
14191, -1.395011e-001, 2.306912e-001, 3.998416e-003
14192, -1.386057e-001, 2.310598e-001, 3.991459e-003
14193, -1.405107e-001, 2.303960e-001, 3.999518e-003
14194, -2.054529e-001, 2.141856e-001, 3.970157e-003
14195, -2.064095e-001, 2.139504e-001, 3.969587e-003
14196, -2.073577e-001, 2.137050e-001, 3.967510e-003
14197, -1.434923e-001, 2.296400e-001, 3.999919e-003
14198, -1.425119e-001, 2.298811e-001, 3.999886e-003
14199, -2.035574e-001, 2.146615e-001, 3.972419e-003
14200, -1.512594e-001, 2.277702e-001, 3.999911e-003
14201, -1.502892e-001, 2.280025e-001, 3.999920e-003
14202, -1.493190e-001, 2.282349e-001, 3.999928e-003
14203, -1.532002e-001, 2.273027e-001, 3.999911e-003
14204, -1.522301e-001, 2.275345e-001, 3.999923e-003
14205, -1.541708e-001, 2.270678e-001, 3.999918e-003
14206, -1.551413e-001, 2.268332e-001, 3.999922e-003
14207, -1.561118e-001, 2.265989e-001, 3.999925e-003
14208, -1.570822e-001, 2.263648e-001, 3.999928e-003
14209, -1.580526e-001, 2.261308e-001, 3.999929e-003
14210, -1.590230e-001, 2.258969e-001, 3.999929e-003
14211, -1.599934e-001, 2.256631e-001, 3.999930e-003
14212, -1.609637e-001, 2.254293e-001, 3.999930e-003
14213, -1.619341e-001, 2.251955e-001, 3.999930e-003
14214, -1.629045e-001, 2.249618e-001, 3.999930e-003
14215, -1.638749e-001, 2.247280e-001, 3.999930e-003
14216, -1.648452e-001, 2.244943e-001, 3.999930e-003
14217, -1.658156e-001, 2.242605e-001, 3.999930e-003
14218, -1.667860e-001, 2.240267e-001, 3.999930e-003
14219, -1.677564e-001, 2.237930e-001, 3.999930e-003
14220, -1.687268e-001, 2.235592e-001, 3.999929e-003
14221, -1.696971e-001, 2.233254e-001, 3.999929e-003
14222, -1.706675e-001, 2.230917e-001, 3.999929e-003
14223, -1.716379e-001, 2.228579e-001, 3.999929e-003
14224, -1.726083e-001, 2.226241e-001, 3.999929e-003
14225, -1.735787e-001, 2.223904e-001, 3.999929e-003
14226, -1.745491e-001, 2.221566e-001, 3.999929e-003
14227, -1.755194e-001, 2.219229e-001, 3.999929e-003
14228, -1.764898e-001, 2.216891e-001, 3.999929e-003
14229, -1.774602e-001, 2.214553e-001, 3.999929e-003
14230, -1.784306e-001, 2.212216e-001, 3.999929e-003
14231, -1.794010e-001, 2.209878e-001, 3.999929e-003
14232, -1.803713e-001, 2.207540e-001, 3.999929e-003
14233, -1.813417e-001, 2.205203e-001, 3.999929e-003
14234, -1.823121e-001, 2.202865e-001, 3.999929e-003
14235, -1.832825e-001, 2.200528e-001, 3.999929e-003
14236, -1.842529e-001, 2.198190e-001, 3.999929e-003
14237, -1.852233e-001, 2.195852e-001, 3.999929e-003
14238, -1.861936e-001, 2.193515e-001, 3.999929e-003
14239, -1.871640e-001, 2.191177e-001, 3.999929e-003
14240, -1.881344e-001, 2.188839e-001, 3.999929e-003
14241, -1.891048e-001, 2.186502e-001, 3.999929e-003
14242, -1.900752e-001, 2.184164e-001, 3.999929e-003
14243, -1.910456e-001, 2.181826e-001, 3.999929e-003
14244, -1.920159e-001, 2.179488e-001, 3.999929e-003
14245, -1.929863e-001, 2.177150e-001, 3.999929e-003
14246, -1.939566e-001, 2.174811e-001, 3.999930e-003
14247, -1.949269e-001, 2.172468e-001, 3.999933e-003
14248, -1.958971e-001, 2.170114e-001, 3.999942e-003
14249, -1.968675e-001, 2.167716e-001, 3.999970e-003
14250, -1.978400e-001, 2.165219e-001, 4.000000e-003
14251, -1.988193e-001, 2.162561e-001, 3.999899e-003
14252, -1.998117e-001, 2.159664e-001, 3.999246e-003
14253, -2.008146e-001, 2.156321e-001, 3.996483e-003
14254, -2.021281e-001, 2.159827e-001, 3.971002e-003
14255, -2.029215e-001, 2.157557e-001, 3.975076e-003
14256, -2.038149e-001, 2.155247e-001, 3.976767e-003
14257, -2.047502e-001, 2.152928e-001, 3.977453e-003
14258, -2.057067e-001, 2.150580e-001, 3.977904e-003
14259, -2.066803e-001, 2.148177e-001, 3.978490e-003
14260, -2.076919e-001, 2.145500e-001, 3.980849e-003
14261, -2.088474e-001, 2.141719e-001, 3.989185e-003
14262, -2.082524e-001, 2.134294e-001, 3.959580e-003
14263, -1.380653e-001, 2.303759e-001, 3.964709e-003
14264, -2.045015e-001, 2.144220e-001, 3.971014e-003
14265, -1.483491e-001, 2.284665e-001, 3.999940e-003
14266, -1.473788e-001, 2.286996e-001, 3.999943e-003
14267, -1.444661e-001, 2.294014e-001, 3.999942e-003
14268, -1.415178e-001, 2.301305e-001, 3.999802e-003
14269, -1.156003e-001, 2.051773e-001, 9.477439e-004
14270, -1.165622e-001, 2.050035e-001, 9.227093e-004
14271, -1.175226e-001, 2.048300e-001, 9.402178e-004
14272, -1.185006e-001, 2.046533e-001, 9.361307e-004
14273, -1.194721e-001, 2.044778e-001, 9.227994e-004
14274, -1.204365e-001, 2.043036e-001, 9.053374e-004
14275, -1.214086e-001, 2.041280e-001, 8.984926e-004
14276, -1.224002e-001, 2.039489e-001, 9.116047e-004
14277, -1.234137e-001, 2.037658e-001, 9.311830e-004
14278, -1.244006e-001, 2.035875e-001, 9.155095e-004
14279, -1.253627e-001, 2.034137e-001, 8.954142e-004
14280, -1.262837e-001, 2.032473e-001, 8.745759e-004
14281, -1.272133e-001, 2.030794e-001, 9.194161e-004
14282, -1.270818e-001, 2.031031e-001, 1.799259e-003
14283, -1.268670e-001, 2.031419e-001, 2.603181e-003
14284, -1.264014e-001, 2.032261e-001, 3.269071e-003
14285, -1.258400e-001, 2.033275e-001, 3.918713e-003
14286, -1.251893e-001, 2.034450e-001, 4.512435e-003
14287, -1.244854e-001, 2.035722e-001, 5.045437e-003
14288, -1.237345e-001, 2.037078e-001, 5.485862e-003
14289, -1.229502e-001, 2.038495e-001, 5.815849e-003
14290, -1.221342e-001, 2.039969e-001, 6.002167e-003
14291, -1.212954e-001, 2.041485e-001, 6.052042e-003
14292, -1.204631e-001, 2.042988e-001, 5.971509e-003
14293, -1.196515e-001, 2.044454e-001, 5.766268e-003
14294, -1.188737e-001, 2.045859e-001, 5.442407e-003
14295, -1.181262e-001, 2.047210e-001, 5.037105e-003
14296, -1.174395e-001, 2.048450e-001, 4.544968e-003
14297, -1.168230e-001, 2.049564e-001, 3.901214e-003
14298, -1.161867e-001, 2.050713e-001, 3.358736e-003
14299, -1.159528e-001, 2.051136e-001, 2.702971e-003
14300, -1.157533e-001, 2.051496e-001, 1.861954e-003
14301, -1.166361e-001, 2.049902e-001, 1.812048e-003
14302, -1.175656e-001, 2.048222e-001, 1.901216e-003
14303, -1.185573e-001, 2.046431e-001, 1.868017e-003
14304, -1.195438e-001, 2.044649e-001, 1.901678e-003
14305, -1.203723e-001, 2.043152e-001, 1.854241e-003
14306, -1.213913e-001, 2.041311e-001, 1.787520e-003
14307, -1.224146e-001, 2.039463e-001, 1.819313e-003
14308, -1.235060e-001, 2.037491e-001, 1.884757e-003
14309, -1.244938e-001, 2.035707e-001, 1.817467e-003
14310, -1.254495e-001, 2.033980e-001, 1.776224e-003
14311, -1.262653e-001, 2.032506e-001, 1.682697e-003
14312, -1.262840e-001, 2.032473e-001, 2.328319e-003
14313, -1.257099e-001, 2.033510e-001, 2.693770e-003
14314, -1.251759e-001, 2.034474e-001, 3.272413e-003
14315, -1.245182e-001, 2.035662e-001, 3.776981e-003
14316, -1.238631e-001, 2.036846e-001, 4.291898e-003
14317, -1.232104e-001, 2.038025e-001, 4.737766e-003
14318, -1.226231e-001, 2.039086e-001, 5.097376e-003
14319, -1.219532e-001, 2.040296e-001, 5.238631e-003
14320, -1.212608e-001, 2.041547e-001, 5.250160e-003
14321, -1.205658e-001, 2.042803e-001, 5.156387e-003
14322, -1.198979e-001, 2.044009e-001, 4.951200e-003
14323, -1.192016e-001, 2.045267e-001, 4.643130e-003
14324, -1.185266e-001, 2.046486e-001, 4.293292e-003
14325, -1.179555e-001, 2.047518e-001, 3.928560e-003
14326, -1.166244e-001, 2.049923e-001, 2.600080e-003
14327, -1.175146e-001, 2.048314e-001, 3.023250e-003
14328, -1.186915e-001, 2.046188e-001, 2.862815e-003
14329, -1.196464e-001, 2.044463e-001, 3.079899e-003
14330, -1.204914e-001, 2.042937e-001, 2.757636e-003
14331, -1.214111e-001, 2.041276e-001, 2.640545e-003
14332, -1.223684e-001, 2.039546e-001, 2.678308e-003
14333, -1.236620e-001, 2.037209e-001, 2.932012e-003
14334, -1.246263e-001, 2.035467e-001, 2.664586e-003
14335, -1.230628e-001, 2.038292e-001, 3.658347e-003
14336, -1.226523e-001, 2.039033e-001, 4.212167e-003
14337, -1.223761e-001, 2.039532e-001, 4.638112e-003
14338, -1.218829e-001, 2.040423e-001, 4.616177e-003
14339, -1.212994e-001, 2.041477e-001, 4.584174e-003
14340, -1.207183e-001, 2.042527e-001, 4.521238e-003
14341, -1.201327e-001, 2.043585e-001, 4.300108e-003
14342, -1.187934e-001, 2.046004e-001, 3.710372e-003
14343, -1.194553e-001, 2.044809e-001, 3.941473e-003
14344, -1.207637e-001, 2.042445e-001, 3.381967e-003
14345, -1.214219e-001, 2.041256e-001, 3.350773e-003
14346, -1.221865e-001, 2.039875e-001, 3.409806e-003
14347, -1.220155e-001, 2.040184e-001, 4.045041e-003
14348, -1.213935e-001, 2.041307e-001, 4.006387e-003
14349, -1.208314e-001, 2.042323e-001, 4.020672e-003
14350, -1.203925e-001, 2.043116e-001, 3.736156e-003
14351, -1.453442e-001, 2.538190e-001, 8.184701e-004
14352, -1.449030e-001, 2.530854e-001, 1.134670e-003
14353, -1.444304e-001, 2.520999e-001, 8.037029e-004
14354, -1.439858e-001, 2.512931e-001, 9.099465e-004
14355, -1.435275e-001, 2.504231e-001, 8.753393e-004
14356, -1.430927e-001, 2.496092e-001, 8.839031e-004
14357, -1.426357e-001, 2.487557e-001, 8.998789e-004
14358, -1.423601e-001, 2.482193e-001, 8.285447e-004
14359, -1.416422e-001, 2.468724e-001, 8.315296e-004
14360, -1.412203e-001, 2.460860e-001, 8.538122e-004
14361, -1.407655e-001, 2.452329e-001, 8.566064e-004
14362, -1.403122e-001, 2.443847e-001, 8.672314e-004
14363, -1.398636e-001, 2.435571e-001, 9.199396e-004
14364, -1.393925e-001, 2.427306e-001, 1.106729e-003
14365, -1.388949e-001, 2.416887e-001, 7.220340e-004
14366, -1.384936e-001, 2.409382e-001, 7.353099e-004
14367, -1.382310e-001, 2.407000e-001, 1.481000e-003
14368, -1.382054e-001, 2.412545e-001, 2.447393e-003
14369, -1.385975e-001, 2.423826e-001, 2.893567e-003
14370, -1.391143e-001, 2.433202e-001, 2.859553e-003
14371, -1.394523e-001, 2.442468e-001, 3.148377e-003
14372, -1.398606e-001, 2.451084e-001, 3.235705e-003
14373, -1.403193e-001, 2.459683e-001, 3.234581e-003
14374, -1.407499e-001, 2.467677e-001, 3.226435e-003
14375, -1.412655e-001, 2.476217e-001, 3.121161e-003
14376, -1.422071e-001, 2.490083e-001, 2.731986e-003
14377, -1.416889e-001, 2.482685e-001, 2.977237e-003
14378, -1.427294e-001, 2.498478e-001, 2.570076e-003
14379, -1.432470e-001, 2.506530e-001, 2.362137e-003
14380, -1.437515e-001, 2.513292e-001, 1.970750e-003
14381, -1.443428e-001, 2.522497e-001, 1.636986e-003
14382, -1.433152e-001, 2.503421e-001, 1.678222e-003
14383, -1.429033e-001, 2.496040e-001, 1.743950e-003
14384, -1.423238e-001, 2.486027e-001, 1.895453e-003
14385, -1.421716e-001, 2.480858e-001, 1.454741e-003
14386, -1.414735e-001, 2.469022e-001, 1.711550e-003
14387, -1.410371e-001, 2.460711e-001, 1.689551e-003
14388, -1.405808e-001, 2.452123e-001, 1.685218e-003
14389, -1.401471e-001, 2.443981e-001, 1.685480e-003
14390, -1.397367e-001, 2.436421e-001, 1.712658e-003
14391, -1.392734e-001, 2.429219e-001, 1.970520e-003
14392, -1.388462e-001, 2.418332e-001, 1.432851e-003
14393, -1.387396e-001, 2.420586e-001, 2.180588e-003
14394, -1.396104e-001, 2.437998e-001, 2.327793e-003
14395, -1.407483e-001, 2.460572e-001, 2.483345e-003
14396, -1.402891e-001, 2.451890e-001, 2.475791e-003
14397, -1.412359e-001, 2.470479e-001, 2.574710e-003
14398, -1.417959e-001, 2.478729e-001, 2.287404e-003
14399, -1.398928e-001, 2.444170e-001, 2.440642e-003
14400, -1.418766e-001, 2.475702e-001, 1.536823e-003
14401, -1.351598e-001, 2.346601e-001, 1.180412e-003
14402, -1.350188e-001, 2.341670e-001, 6.095313e-004
14403, -1.342567e-001, 2.324258e-001, 9.569482e-004
14404, -1.339934e-001, 2.317324e-001, 9.825105e-004
14405, -1.337291e-001, 2.309603e-001, 9.329767e-004
14406, -1.335059e-001, 2.302457e-001, 8.422560e-004
14407, -1.331675e-001, 2.291037e-001, 7.896032e-004
14408, -1.332337e-001, 2.298263e-001, 1.602366e-003
14409, -1.330536e-001, 2.302767e-001, 2.576562e-003
14410, -1.327894e-001, 2.303525e-001, 3.184181e-003
14411, -1.333734e-001, 2.317391e-001, 2.956148e-003
14412, -1.332021e-001, 2.309805e-001, 2.762595e-003
14413, -1.335897e-001, 2.325085e-001, 3.088539e-003
14414, -1.340552e-001, 2.332579e-001, 2.741357e-003
14415, -1.347052e-001, 2.340512e-001, 1.915846e-003
14416, -1.337773e-001, 2.318384e-001, 2.055623e-003
14417, -1.342321e-001, 2.327826e-001, 1.734533e-003
14418, -1.335185e-001, 2.309184e-001, 1.848702e-003
14419, -1.346544e-001, 2.334741e-001, 1.102867e-003
14420, -1.259128e-001, 2.234734e-001, 6.926809e-003
14421, -1.249995e-001, 2.236649e-001, 6.999578e-003
14422, -1.267808e-001, 2.232128e-001, 6.734338e-003
14423, -1.275765e-001, 2.229054e-001, 6.438106e-003
14424, -1.282869e-001, 2.224332e-001, 6.044279e-003
14425, -1.289566e-001, 2.218663e-001, 5.530827e-003
14426, -1.295050e-001, 2.208942e-001, 4.895813e-003
14427, -1.297518e-001, 2.200208e-001, 4.452647e-003
14428, -1.298628e-001, 2.193890e-001, 4.169334e-003
14429, -1.297293e-001, 2.185727e-001, 4.150733e-003
14430, -1.294797e-001, 2.176462e-001, 4.258507e-003
14431, -1.291889e-001, 2.167149e-001, 4.411338e-003
14432, -1.288662e-001, 2.157967e-001, 4.595036e-003
14433, -1.285240e-001, 2.148825e-001, 4.787839e-003
14434, -1.281537e-001, 2.139819e-001, 4.996870e-003
14435, -1.277480e-001, 2.131059e-001, 5.224610e-003
14436, -1.273119e-001, 2.122528e-001, 5.459390e-003
14437, -1.268598e-001, 2.114359e-001, 5.686978e-003
14438, -1.264154e-001, 2.106850e-001, 5.893142e-003
14439, -1.259881e-001, 2.100528e-001, 6.079666e-003
14440, -1.245060e-001, 2.087923e-001, 6.633551e-003
14441, -1.251134e-001, 2.095663e-001, 6.460289e-003
14442, -1.238820e-001, 2.081635e-001, 6.782112e-003
14443, -1.231850e-001, 2.076807e-001, 6.907735e-003
14444, -1.222283e-001, 2.075146e-001, 6.996514e-003
14445, -1.212787e-001, 2.077989e-001, 6.958172e-003
14446, -1.205827e-001, 2.082041e-001, 6.832739e-003
14447, -1.201167e-001, 2.086349e-001, 6.691187e-003
14448, -1.196513e-001, 2.103785e-001, 6.404970e-003
14449, -1.199299e-001, 2.094497e-001, 6.581184e-003
14450, -1.194072e-001, 2.113118e-001, 6.210086e-003
14451, -1.191801e-001, 2.122563e-001, 5.990261e-003
14452, -1.189851e-001, 2.132057e-001, 5.756801e-003
14453, -1.188326e-001, 2.141600e-001, 5.521972e-003
14454, -1.187229e-001, 2.151214e-001, 5.292905e-003
14455, -1.186506e-001, 2.160916e-001, 5.071813e-003
14456, -1.186155e-001, 2.170665e-001, 4.865693e-003
14457, -1.186190e-001, 2.180461e-001, 4.682688e-003
14458, -1.186590e-001, 2.190304e-001, 4.527385e-003
14459, -1.187207e-001, 2.200427e-001, 4.382879e-003
14460, -1.189534e-001, 2.213083e-001, 4.387929e-003
14461, -1.191360e-001, 2.221452e-001, 4.426107e-003
14462, -1.195392e-001, 2.228827e-001, 4.732955e-003
14463, -1.200353e-001, 2.234669e-001, 5.120326e-003
14464, -1.206887e-001, 2.238114e-001, 5.606486e-003
14465, -1.214220e-001, 2.239969e-001, 6.060622e-003
14466, -1.221455e-001, 2.238843e-001, 6.428313e-003
14467, -1.240659e-001, 2.237897e-001, 6.946467e-003
14468, -1.231222e-001, 2.238437e-001, 6.763999e-003
14469, -1.254024e-001, 2.103396e-001, 6.397011e-003
14470, -1.265627e-001, 2.222327e-001, 6.745673e-003
14471, -1.257548e-001, 2.224358e-001, 6.922514e-003
14472, -1.284433e-001, 2.209072e-001, 5.774924e-003
14473, -1.278481e-001, 2.215404e-001, 6.195722e-003
14474, -1.289721e-001, 2.202350e-001, 5.279923e-003
14475, -1.293133e-001, 2.195013e-001, 4.834746e-003
14476, -1.293242e-001, 2.186976e-001, 4.668665e-003
14477, -1.282789e-001, 2.160354e-001, 5.223105e-003
14478, -1.286482e-001, 2.169114e-001, 5.030107e-003
14479, -1.279223e-001, 2.151444e-001, 5.388764e-003
14480, -1.275384e-001, 2.142604e-001, 5.564293e-003
14481, -1.271166e-001, 2.134006e-001, 5.755036e-003
14482, -1.266722e-001, 2.125633e-001, 5.944386e-003
14483, -1.262304e-001, 2.117684e-001, 6.117150e-003
14484, -1.258358e-001, 2.110412e-001, 6.254223e-003
14485, -1.229277e-001, 2.082942e-001, 6.957463e-003
14486, -1.233060e-001, 2.087737e-001, 6.919646e-003
14487, -1.237652e-001, 2.093967e-001, 6.858842e-003
14488, -1.242670e-001, 2.100879e-001, 6.772615e-003
14489, -1.215508e-001, 2.086045e-001, 6.970718e-003
14490, -1.223035e-001, 2.083931e-001, 6.998626e-003
14491, -1.208979e-001, 2.087857e-001, 6.875501e-003
14492, -1.205330e-001, 2.106847e-001, 6.704932e-003
14493, -1.209091e-001, 2.096634e-001, 6.846199e-003
14494, -1.203328e-001, 2.116116e-001, 6.585606e-003
14495, -1.196549e-001, 2.144594e-001, 6.035327e-003
14496, -1.198445e-001, 2.135113e-001, 6.230380e-003
14497, -1.195214e-001, 2.154087e-001, 5.848594e-003
14498, -1.194258e-001, 2.163700e-001, 5.665490e-003
14499, -1.193696e-001, 2.173410e-001, 5.492859e-003
14500, -1.193504e-001, 2.183213e-001, 5.334649e-003
14501, -1.193665e-001, 2.192999e-001, 5.196088e-003
14502, -1.194284e-001, 2.203039e-001, 5.087533e-003
14503, -1.195461e-001, 2.213904e-001, 5.013354e-003
14504, -1.198948e-001, 2.224412e-001, 5.161047e-003
14505, -1.202345e-001, 2.229521e-001, 5.374031e-003
14506, -1.208052e-001, 2.231455e-001, 5.773397e-003
14507, -1.240232e-001, 2.226976e-001, 6.963706e-003
14508, -1.231587e-001, 2.227207e-001, 6.822401e-003
14509, -1.248971e-001, 2.225895e-001, 6.998002e-003
14510, -1.272689e-001, 2.221038e-001, 6.504177e-003
14511, -1.289832e-001, 2.177972e-001, 4.857574e-003
14512, -1.200788e-001, 2.125643e-001, 6.419044e-003
14513, -1.213922e-001, 2.232930e-001, 6.114973e-003
14514, -1.247346e-001, 2.107877e-001, 6.675889e-003
14515, -1.287983e-001, 2.191024e-001, 5.253396e-003
14516, -1.284767e-001, 2.195747e-001, 5.580588e-003
14517, -1.278316e-001, 2.199674e-001, 6.049906e-003
14518, -1.268307e-001, 2.146170e-001, 6.069472e-003
14519, -1.271939e-001, 2.154913e-001, 5.948865e-003
14520, -1.274682e-001, 2.164067e-001, 5.880985e-003
14521, -1.279892e-001, 2.172274e-001, 5.627272e-003
14522, -1.259561e-001, 2.129252e-001, 6.358451e-003
14523, -1.264018e-001, 2.137691e-001, 6.217503e-003
14524, -1.255181e-001, 2.121145e-001, 6.482869e-003
14525, -1.252627e-001, 2.114102e-001, 6.532819e-003
14526, -1.210254e-001, 2.128612e-001, 6.733434e-003
14527, -1.214187e-001, 2.118422e-001, 6.869545e-003
14528, -1.229695e-001, 2.098546e-001, 6.979581e-003
14529, -1.234766e-001, 2.105753e-001, 6.941222e-003
14530, -1.217703e-001, 2.094166e-001, 6.976921e-003
14531, -1.202858e-001, 2.165882e-001, 6.171365e-003
14532, -1.203943e-001, 2.156371e-001, 6.311270e-003
14533, -1.225882e-001, 2.091154e-001, 6.993969e-003
14534, -1.215713e-001, 2.224869e-001, 6.282387e-003
14535, -1.209039e-001, 2.223354e-001, 5.931479e-003
14536, -1.213537e-001, 2.110113e-001, 6.885400e-003
14537, -1.220533e-001, 2.102563e-001, 6.986241e-003
14538, -1.205357e-001, 2.147029e-001, 6.448827e-003
14539, -1.207442e-001, 2.137791e-001, 6.592607e-003
14540, -1.201750e-001, 2.185439e-001, 5.904155e-003
14541, -1.202197e-001, 2.175557e-001, 6.038481e-003
14542, -1.201337e-001, 2.194837e-001, 5.766606e-003
14543, -1.201576e-001, 2.204404e-001, 5.662992e-003
14544, -1.202219e-001, 2.213881e-001, 5.585059e-003
14545, -1.203166e-001, 2.221681e-001, 5.550370e-003
14546, -1.239780e-001, 2.216482e-001, 6.976766e-003
14547, -1.231566e-001, 2.216664e-001, 6.862338e-003
14548, -1.248135e-001, 2.215660e-001, 6.994909e-003
14549, -1.283932e-001, 2.180024e-001, 5.425462e-003
14550, -1.272718e-001, 2.207071e-001, 6.398544e-003
14551, -1.256516e-001, 2.214402e-001, 6.910786e-003
14552, -1.223157e-001, 2.226609e-001, 6.580910e-003
14553, -1.265091e-001, 2.213009e-001, 6.713363e-003
14554, -1.240013e-001, 2.113414e-001, 6.880980e-003
14555, -1.278818e-001, 2.182458e-001, 5.828518e-003
14556, -1.260573e-001, 2.149968e-001, 6.475414e-003
14557, -1.264256e-001, 2.158131e-001, 6.381878e-003
14558, -1.246788e-001, 2.123058e-001, 6.769753e-003
14559, -1.267324e-001, 2.165677e-001, 6.303553e-003
14560, -1.251450e-001, 2.132835e-001, 6.688301e-003
14561, -1.262312e-001, 2.203076e-001, 6.741197e-003
14562, -1.255077e-001, 2.204694e-001, 6.905719e-003
14563, -1.226878e-001, 2.110063e-001, 6.999804e-003
14564, -1.214248e-001, 2.149184e-001, 6.741140e-003
14565, -1.216201e-001, 2.140448e-001, 6.828834e-003
14566, -1.219197e-001, 2.132552e-001, 6.912498e-003
14567, -1.216148e-001, 2.215630e-001, 6.379990e-003
14568, -1.209041e-001, 2.214634e-001, 6.025981e-003
14569, -1.208811e-001, 2.205463e-001, 6.106824e-003
14570, -1.208933e-001, 2.196432e-001, 6.200333e-003
14571, -1.222739e-001, 2.124926e-001, 6.972562e-003
14572, -1.220987e-001, 2.114919e-001, 6.973044e-003
14573, -1.269395e-001, 2.172417e-001, 6.262346e-003
14574, -1.213541e-001, 2.157855e-001, 6.674493e-003
14575, -1.211066e-001, 2.188190e-001, 6.374405e-003
14576, -1.239260e-001, 2.206507e-001, 6.985921e-003
14577, -1.231251e-001, 2.206745e-001, 6.889998e-003
14578, -1.247278e-001, 2.205862e-001, 6.990904e-003
14579, -1.281434e-001, 2.190194e-001, 5.746965e-003
14580, -1.256170e-001, 2.141569e-001, 6.584846e-003
14581, -1.211498e-001, 2.177361e-001, 6.475917e-003
14582, -1.212307e-001, 2.167404e-001, 6.575365e-003
14583, -1.268363e-001, 2.200558e-001, 6.528339e-003
14584, -1.276657e-001, 2.191714e-001, 6.062529e-003
14585, -1.272519e-001, 2.197262e-001, 6.327609e-003
14586, -1.223565e-001, 2.216356e-001, 6.657337e-003
14587, -1.231488e-001, 2.117387e-001, 6.989908e-003
14588, -1.242373e-001, 2.137334e-001, 6.914247e-003
14589, -1.247925e-001, 2.145804e-001, 6.840000e-003
14590, -1.224725e-001, 2.158611e-001, 6.924901e-003
14591, -1.222731e-001, 2.150701e-001, 6.916471e-003
14592, -1.233979e-001, 2.127668e-001, 6.986273e-003
14593, -1.261143e-001, 2.195245e-001, 6.734395e-003
14594, -1.254402e-001, 2.195637e-001, 6.889356e-003
14595, -1.215946e-001, 2.206512e-001, 6.442283e-003
14596, -1.222094e-001, 2.168374e-001, 6.847093e-003
14597, -1.221390e-001, 2.187977e-001, 6.744816e-003
14598, -1.221303e-001, 2.178101e-001, 6.788973e-003
14599, -1.215583e-001, 2.198552e-001, 6.486243e-003
14600, -1.271195e-001, 2.191879e-001, 6.343846e-003
14601, -1.266387e-001, 2.195004e-001, 6.564586e-003
14602, -1.223375e-001, 2.206762e-001, 6.704773e-003
14603, -1.238859e-001, 2.197103e-001, 6.992865e-003
14604, -1.230814e-001, 2.197331e-001, 6.911160e-003
14605, -1.246700e-001, 2.196793e-001, 6.984792e-003
14606, -1.256224e-001, 2.162059e-001, 6.703467e-003
14607, -1.259617e-001, 2.169968e-001, 6.642265e-003
14608, -1.275108e-001, 2.185948e-001, 6.091069e-003
14609, -1.228144e-001, 2.136359e-001, 6.993968e-003
14610, -1.252461e-001, 2.153976e-001, 6.767478e-003
14611, -1.224122e-001, 2.142536e-001, 6.954578e-003
14612, -1.263536e-001, 2.177577e-001, 6.553666e-003
14613, -1.269289e-001, 2.184097e-001, 6.366564e-003
14614, -1.222847e-001, 2.197671e-001, 6.736723e-003
14615, -1.234786e-001, 2.142812e-001, 6.995594e-003
14616, -1.255308e-001, 2.185252e-001, 6.834443e-003
14617, -1.246371e-001, 2.188524e-001, 6.976280e-003
14618, -1.240106e-001, 2.150190e-001, 6.970617e-003
14619, -1.244512e-001, 2.157815e-001, 6.936761e-003
14620, -1.250975e-001, 2.175059e-001, 6.884152e-003
14621, -1.230707e-001, 2.169959e-001, 6.971080e-003
14622, -1.230991e-001, 2.163304e-001, 6.982867e-003
14623, -1.247821e-001, 2.166007e-001, 6.910025e-003
14624, -1.230349e-001, 2.187958e-001, 6.929513e-003
14625, -1.230613e-001, 2.178805e-001, 6.953893e-003
14626, -1.262152e-001, 2.189197e-001, 6.672274e-003
14627, -1.238838e-001, 2.187903e-001, 6.998294e-003
14628, -1.232680e-001, 2.154217e-001, 6.998133e-003
14629, -1.228372e-001, 2.147504e-001, 6.984452e-003
14630, -1.225010e-001, 2.119090e-001, 6.993910e-003
14631, -1.240305e-001, 2.179155e-001, 6.998490e-003
14632, -1.239088e-001, 2.169001e-001, 6.996963e-003
14633, -1.237005e-001, 2.160927e-001, 6.998505e-003
14634, -1.274469e-001, 2.177443e-001, 6.040219e-003
14635, -1.371848e-001, 2.386579e-001, 1.300319e-003
14636, -1.371751e-001, 2.392066e-001, 2.299039e-003
14637, -1.371646e-001, 2.399893e-001, 3.182972e-003
14638, -1.373044e-001, 2.410348e-001, 3.819255e-003
14639, -1.375464e-001, 2.421129e-001, 4.235643e-003
14640, -1.378807e-001, 2.431797e-001, 4.494431e-003
14641, -1.382889e-001, 2.442142e-001, 4.640800e-003
14642, -1.387525e-001, 2.452103e-001, 4.706750e-003
14643, -1.392575e-001, 2.461704e-001, 4.713010e-003
14644, -1.397939e-001, 2.470988e-001, 4.672026e-003
14645, -1.403545e-001, 2.480004e-001, 4.591718e-003
14646, -1.409342e-001, 2.488793e-001, 4.475952e-003
14647, -1.415299e-001, 2.497386e-001, 4.325284e-003
14648, -1.421394e-001, 2.505804e-001, 4.137917e-003
14649, -1.427614e-001, 2.514055e-001, 3.908671e-003
14650, -1.433949e-001, 2.522140e-001, 3.628494e-003
14651, -1.440364e-001, 2.530041e-001, 3.285852e-003
14652, -1.446710e-001, 2.537655e-001, 2.873619e-003
14653, -1.452573e-001, 2.544658e-001, 2.412322e-003
14654, -1.457336e-001, 2.550642e-001, 1.992962e-003
14655, -1.462207e-001, 2.556051e-001, 1.258808e-003
14656, -1.464327e-001, 2.558390e-001, 7.187157e-004
14657, -1.366653e-001, 2.375299e-001, 8.351529e-004
14658, -1.244684e-001, 2.441532e-001, 9.962137e-004
14659, -1.246558e-001, 2.440534e-001, 1.972145e-003
14660, -1.249639e-001, 2.438893e-001, 2.907923e-003
14661, -1.253863e-001, 2.436643e-001, 3.784499e-003
14662, -1.259146e-001, 2.433829e-001, 4.584031e-003
14663, -1.265379e-001, 2.430509e-001, 5.290249e-003
14664, -1.272436e-001, 2.426750e-001, 5.888776e-003
14665, -1.280172e-001, 2.422629e-001, 6.367424e-003
14666, -1.288432e-001, 2.418230e-001, 6.716454e-003
14667, -1.297048e-001, 2.413642e-001, 6.928786e-003
14668, -1.305844e-001, 2.408959e-001, 7.000000e-003
14669, -1.314634e-001, 2.404253e-001, 6.928542e-003
14670, -1.323203e-001, 2.399579e-001, 6.716003e-003
14671, -1.331340e-001, 2.395069e-001, 6.369291e-003
14672, -1.338941e-001, 2.390950e-001, 5.899113e-003
14673, -1.345809e-001, 2.387109e-001, 5.315192e-003
14674, -1.352201e-001, 2.384495e-001, 4.638989e-003
14675, -1.357704e-001, 2.381606e-001, 3.823329e-003
14676, -1.361022e-001, 2.377848e-001, 2.981761e-003
14677, -1.366677e-001, 2.378883e-001, 1.726942e-003
14678, -1.249394e-001, 2.450374e-001, 9.962262e-004
14679, -1.254104e-001, 2.459215e-001, 9.962431e-004
14680, -1.258813e-001, 2.468057e-001, 9.962635e-004
14681, -1.263523e-001, 2.476898e-001, 9.962844e-004
14682, -1.268232e-001, 2.485739e-001, 9.963053e-004
14683, -1.272942e-001, 2.494581e-001, 9.963229e-004
14684, -1.277651e-001, 2.503422e-001, 9.963348e-004
14685, -1.282361e-001, 2.512264e-001, 9.963411e-004
14686, -1.287070e-001, 2.521105e-001, 9.963439e-004
14687, -1.291780e-001, 2.529947e-001, 9.963450e-004
14688, -1.296489e-001, 2.538788e-001, 9.963455e-004
14689, -1.301199e-001, 2.547629e-001, 9.963456e-004
14690, -1.305908e-001, 2.556471e-001, 9.963457e-004
14691, -1.310618e-001, 2.565312e-001, 9.963457e-004
14692, -1.315327e-001, 2.574154e-001, 9.963457e-004
14693, -1.320037e-001, 2.582995e-001, 9.963457e-004
14694, -1.324746e-001, 2.591836e-001, 9.963457e-004
14695, -1.329456e-001, 2.600678e-001, 9.963457e-004
14696, -1.334165e-001, 2.609519e-001, 9.963457e-004
14697, -1.338875e-001, 2.618361e-001, 9.963457e-004
14698, -1.343584e-001, 2.627202e-001, 9.963457e-004
14699, -1.348294e-001, 2.636044e-001, 9.963457e-004
14700, -1.353003e-001, 2.644885e-001, 9.963457e-004
14701, -1.357713e-001, 2.653726e-001, 9.963457e-004
14702, -1.362422e-001, 2.662568e-001, 9.963457e-004
14703, -1.367132e-001, 2.671409e-001, 9.963457e-004
14704, -1.371842e-001, 2.680251e-001, 9.963457e-004
14705, -1.376551e-001, 2.689092e-001, 9.963457e-004
14706, -1.381261e-001, 2.697933e-001, 9.963457e-004
14707, -1.385970e-001, 2.706775e-001, 9.963457e-004
14708, -1.390680e-001, 2.715616e-001, 9.963457e-004
14709, -1.395389e-001, 2.724458e-001, 9.963457e-004
14710, -1.400099e-001, 2.733299e-001, 9.963457e-004
14711, -1.404808e-001, 2.742140e-001, 9.963457e-004
14712, -1.409518e-001, 2.750982e-001, 9.963457e-004
14713, -1.414227e-001, 2.759823e-001, 9.963457e-004
14714, -1.418937e-001, 2.768665e-001, 9.963457e-004
14715, -1.423646e-001, 2.777506e-001, 9.963457e-004
14716, -1.428356e-001, 2.786348e-001, 9.963457e-004
14717, -1.433065e-001, 2.795189e-001, 9.963457e-004
14718, -1.437775e-001, 2.804030e-001, 9.963457e-004
14719, -1.442484e-001, 2.812872e-001, 9.963457e-004
14720, -1.447194e-001, 2.821713e-001, 9.963457e-004
14721, -1.451903e-001, 2.830555e-001, 9.963457e-004
14722, -1.456613e-001, 2.839396e-001, 9.963457e-004
14723, -1.461322e-001, 2.848237e-001, 9.963457e-004
14724, -1.466032e-001, 2.857079e-001, 9.963457e-004
14725, -1.470741e-001, 2.865920e-001, 9.963457e-004
14726, -1.475451e-001, 2.874762e-001, 9.963457e-004
14727, -1.480160e-001, 2.883603e-001, 9.963457e-004
14728, -1.484870e-001, 2.892445e-001, 9.963457e-004
14729, -1.489579e-001, 2.901286e-001, 9.963457e-004
14730, -1.494289e-001, 2.910127e-001, 9.963457e-004
14731, -1.498998e-001, 2.918969e-001, 9.963457e-004
14732, -1.503708e-001, 2.927810e-001, 9.963457e-004
14733, -1.508417e-001, 2.936652e-001, 9.963457e-004
14734, -1.513127e-001, 2.945493e-001, 9.963457e-004
14735, -1.517836e-001, 2.954334e-001, 9.963457e-004
14736, -1.522546e-001, 2.963176e-001, 9.963457e-004
14737, -1.527255e-001, 2.972017e-001, 9.963457e-004
14738, -1.531965e-001, 2.980859e-001, 9.963457e-004
14739, -1.536674e-001, 2.989700e-001, 9.963457e-004
14740, -1.541384e-001, 2.998542e-001, 9.963457e-004
14741, -1.546093e-001, 3.007383e-001, 9.963457e-004
14742, -1.550803e-001, 3.016224e-001, 9.963457e-004
14743, -1.555513e-001, 3.025066e-001, 9.963457e-004
14744, -1.560222e-001, 3.033907e-001, 9.963457e-004
14745, -1.564932e-001, 3.042749e-001, 9.963457e-004
14746, -1.569641e-001, 3.051590e-001, 9.963457e-004
14747, -1.574351e-001, 3.060431e-001, 9.963457e-004
14748, -1.579060e-001, 3.069273e-001, 9.963457e-004
14749, -1.583770e-001, 3.078114e-001, 9.963457e-004
14750, -1.588479e-001, 3.086956e-001, 9.963457e-004
14751, -1.593189e-001, 3.095797e-001, 9.963457e-004
14752, -1.597898e-001, 3.104639e-001, 9.963457e-004
14753, -1.602608e-001, 3.113480e-001, 9.963457e-004
14754, -1.607317e-001, 3.122321e-001, 9.963457e-004
14755, -1.612027e-001, 3.131163e-001, 9.963457e-004
14756, -1.616736e-001, 3.140004e-001, 9.963457e-004
14757, -1.621446e-001, 3.148846e-001, 9.963457e-004
14758, -1.626155e-001, 3.157687e-001, 9.963457e-004
14759, -1.630865e-001, 3.166528e-001, 9.963457e-004
14760, -1.635574e-001, 3.175370e-001, 9.963457e-004
14761, -1.640284e-001, 3.184211e-001, 9.963457e-004
14762, -1.644993e-001, 3.193053e-001, 9.963457e-004
14763, -1.649703e-001, 3.201894e-001, 9.963457e-004
14764, -1.654412e-001, 3.210735e-001, 9.963457e-004
14765, -1.659122e-001, 3.219577e-001, 9.963457e-004
14766, -1.663831e-001, 3.228418e-001, 9.963457e-004
14767, -1.668541e-001, 3.237260e-001, 9.963457e-004
14768, -1.673250e-001, 3.246101e-001, 9.963457e-004
14769, -1.677960e-001, 3.254943e-001, 9.963457e-004
14770, -1.682669e-001, 3.263784e-001, 9.963457e-004
14771, -1.687379e-001, 3.272625e-001, 9.963457e-004
14772, -1.692088e-001, 3.281467e-001, 9.963457e-004
14773, -1.696798e-001, 3.290308e-001, 9.963457e-004
14774, -1.701507e-001, 3.299150e-001, 9.963457e-004
14775, -1.706217e-001, 3.307991e-001, 9.963457e-004
14776, -1.710926e-001, 3.316832e-001, 9.963457e-004
14777, -1.715636e-001, 3.325674e-001, 9.963457e-004
14778, -1.720345e-001, 3.334515e-001, 9.963457e-004
14779, -1.725055e-001, 3.343357e-001, 9.963457e-004
14780, -1.729765e-001, 3.352198e-001, 9.963457e-004
14781, -1.734474e-001, 3.361040e-001, 9.963457e-004
14782, -1.739184e-001, 3.369881e-001, 9.963457e-004
14783, -1.743893e-001, 3.378722e-001, 9.963457e-004
14784, -1.748603e-001, 3.387564e-001, 9.963457e-004
14785, -1.753312e-001, 3.396405e-001, 9.963457e-004
14786, -1.758022e-001, 3.405247e-001, 9.963457e-004
14787, -1.762731e-001, 3.414088e-001, 9.963457e-004
14788, -1.767441e-001, 3.422929e-001, 9.963457e-004
14789, -1.772150e-001, 3.431771e-001, 9.963457e-004
14790, -1.776860e-001, 3.440612e-001, 9.963457e-004
14791, -1.781569e-001, 3.449454e-001, 9.963457e-004
14792, -1.786279e-001, 3.458295e-001, 9.963457e-004
14793, -1.790988e-001, 3.467137e-001, 9.963457e-004
14794, -1.795698e-001, 3.475978e-001, 9.963457e-004
14795, -1.800407e-001, 3.484819e-001, 9.963457e-004
14796, -1.805117e-001, 3.493661e-001, 9.963457e-004
14797, -1.809826e-001, 3.502502e-001, 9.963457e-004
14798, -1.814536e-001, 3.511344e-001, 9.963457e-004
14799, -1.819245e-001, 3.520185e-001, 9.963457e-004
14800, -1.823955e-001, 3.529026e-001, 9.963457e-004
14801, -1.828664e-001, 3.537868e-001, 9.963457e-004
14802, -1.833374e-001, 3.546709e-001, 9.963457e-004
14803, -1.838083e-001, 3.555551e-001, 9.963457e-004
14804, -1.842793e-001, 3.564392e-001, 9.963457e-004
14805, -1.847502e-001, 3.573233e-001, 9.963457e-004
14806, -1.852212e-001, 3.582075e-001, 9.963457e-004
14807, -1.856921e-001, 3.590916e-001, 9.963457e-004
14808, -1.861631e-001, 3.599758e-001, 9.963457e-004
14809, -1.866340e-001, 3.608599e-001, 9.963457e-004
14810, -1.871050e-001, 3.617441e-001, 9.963457e-004
14811, -1.875759e-001, 3.626282e-001, 9.963457e-004
14812, -1.880469e-001, 3.635123e-001, 9.963457e-004
14813, -1.885178e-001, 3.643965e-001, 9.963457e-004
14814, -1.889888e-001, 3.652806e-001, 9.963457e-004
14815, -1.894597e-001, 3.661648e-001, 9.963457e-004
14816, -1.899307e-001, 3.670489e-001, 9.963457e-004
14817, -1.904016e-001, 3.679330e-001, 9.963457e-004
14818, -1.908726e-001, 3.688172e-001, 9.963457e-004
14819, -1.913436e-001, 3.697013e-001, 9.963457e-004
14820, -1.918145e-001, 3.705855e-001, 9.963457e-004
14821, -1.922855e-001, 3.714696e-001, 9.963457e-004
14822, -1.927564e-001, 3.723538e-001, 9.963457e-004
14823, -1.932274e-001, 3.732379e-001, 9.963457e-004
14824, -1.936983e-001, 3.741220e-001, 9.963457e-004
14825, -1.941693e-001, 3.750062e-001, 9.963457e-004
14826, -1.946402e-001, 3.758903e-001, 9.963457e-004
14827, -1.951112e-001, 3.767745e-001, 9.963457e-004
14828, -1.955821e-001, 3.776586e-001, 9.963457e-004
14829, -1.960531e-001, 3.785427e-001, 9.963457e-004
14830, -1.965240e-001, 3.794269e-001, 9.963457e-004
14831, -1.969950e-001, 3.803110e-001, 9.963457e-004
14832, -1.974659e-001, 3.811952e-001, 9.963457e-004
14833, -1.979369e-001, 3.820793e-001, 9.963457e-004
14834, -1.984078e-001, 3.829635e-001, 9.963457e-004
14835, -1.988788e-001, 3.838476e-001, 9.963457e-004
14836, -1.993497e-001, 3.847317e-001, 9.963457e-004
14837, -1.998207e-001, 3.856159e-001, 9.963457e-004
14838, -2.002916e-001, 3.865000e-001, 9.963457e-004
14839, -2.007626e-001, 3.873842e-001, 9.963457e-004
14840, -2.012335e-001, 3.882683e-001, 9.963457e-004
14841, -2.017045e-001, 3.891524e-001, 9.963457e-004
14842, -2.021754e-001, 3.900366e-001, 9.963457e-004
14843, -2.026464e-001, 3.909207e-001, 9.963457e-004
14844, -2.031173e-001, 3.918049e-001, 9.963457e-004
14845, -2.035883e-001, 3.926890e-001, 9.963457e-004
14846, -2.040592e-001, 3.935732e-001, 9.963457e-004
14847, -2.045302e-001, 3.944573e-001, 9.963457e-004
14848, -2.050011e-001, 3.953414e-001, 9.963457e-004
14849, -2.054721e-001, 3.962256e-001, 9.963457e-004
14850, -2.059430e-001, 3.971097e-001, 9.963457e-004
14851, -2.064140e-001, 3.979939e-001, 9.963457e-004
14852, -2.068849e-001, 3.988780e-001, 9.963457e-004
14853, -2.073559e-001, 3.997621e-001, 9.963457e-004
14854, -2.078268e-001, 4.006463e-001, 9.963457e-004
14855, -2.082978e-001, 4.015304e-001, 9.963457e-004
14856, -2.087688e-001, 4.024146e-001, 9.963457e-004
14857, -2.092397e-001, 4.032987e-001, 9.963457e-004
14858, -2.097107e-001, 4.041828e-001, 9.963457e-004
14859, -2.101816e-001, 4.050670e-001, 9.963457e-004
14860, -2.106526e-001, 4.059511e-001, 9.963457e-004
14861, -2.111235e-001, 4.068353e-001, 9.963457e-004
14862, -2.115945e-001, 4.077194e-001, 9.963425e-004
14863, -2.120654e-001, 4.086036e-001, 9.963290e-004
14864, -2.125364e-001, 4.094877e-001, 9.963036e-004
14865, -2.130073e-001, 4.103719e-001, 9.962733e-004
14866, -2.134783e-001, 4.112560e-001, 9.962452e-004
14867, -2.139492e-001, 4.121401e-001, 9.962208e-004
14868, -2.141366e-001, 4.120403e-001, 1.972165e-003
14869, -2.144447e-001, 4.118763e-001, 2.907946e-003
14870, -2.148672e-001, 4.116513e-001, 3.784521e-003
14871, -2.153955e-001, 4.113700e-001, 4.584047e-003
14872, -2.160188e-001, 4.110381e-001, 5.290255e-003
14873, -2.167245e-001, 4.106623e-001, 5.888779e-003
14874, -2.174982e-001, 4.102503e-001, 6.367426e-003
14875, -2.183242e-001, 4.098104e-001, 6.716450e-003
14876, -2.191855e-001, 4.093516e-001, 6.928750e-003
14877, -2.200648e-001, 4.088833e-001, 7.000000e-003
14878, -2.209440e-001, 4.084150e-001, 6.928751e-003
14879, -2.218054e-001, 4.079561e-001, 6.716451e-003
14880, -2.226313e-001, 4.075161e-001, 6.367426e-003
14881, -2.234049e-001, 4.071040e-001, 5.888777e-003
14882, -2.241105e-001, 4.067280e-001, 5.290248e-003
14883, -2.247339e-001, 4.063960e-001, 4.584031e-003
14884, -2.252622e-001, 4.061148e-001, 3.784492e-003
14885, -2.256849e-001, 4.058902e-001, 2.907912e-003
14886, -2.259932e-001, 4.057267e-001, 1.972138e-003
14887, -2.261809e-001, 4.056274e-001, 9.962057e-004
14888, -2.257111e-001, 4.047455e-001, 9.962146e-004
14889, -2.252415e-001, 4.038638e-001, 9.962307e-004
14890, -2.247719e-001, 4.029822e-001, 9.962541e-004
14891, -2.243023e-001, 4.021007e-001, 9.962803e-004
14892, -2.238329e-001, 4.012193e-001, 9.963061e-004
14893, -2.233634e-001, 4.003380e-001, 9.963272e-004
14894, -2.228939e-001, 3.994566e-001, 9.963414e-004
14895, -2.224244e-001, 3.985752e-001, 9.963490e-004
14896, -2.219550e-001, 3.976939e-001, 9.963525e-004
14897, -2.214855e-001, 3.968125e-001, 9.963540e-004
14898, -2.210160e-001, 3.959311e-001, 9.963545e-004
14899, -2.205465e-001, 3.950497e-001, 9.963547e-004
14900, -2.200770e-001, 3.941683e-001, 9.963548e-004
14901, -2.196075e-001, 3.932869e-001, 9.963548e-004
14902, -2.191381e-001, 3.924056e-001, 9.963548e-004
14903, -2.186686e-001, 3.915242e-001, 9.963548e-004
14904, -2.181991e-001, 3.906428e-001, 9.963548e-004
14905, -2.177296e-001, 3.897614e-001, 9.963548e-004
14906, -2.172601e-001, 3.888800e-001, 9.963548e-004
14907, -2.167907e-001, 3.879986e-001, 9.963548e-004
14908, -2.163212e-001, 3.871173e-001, 9.963548e-004
14909, -2.158517e-001, 3.862359e-001, 9.963548e-004
14910, -2.153822e-001, 3.853545e-001, 9.963548e-004
14911, -2.149127e-001, 3.844731e-001, 9.963548e-004
14912, -2.144432e-001, 3.835917e-001, 9.963548e-004
14913, -2.139738e-001, 3.827103e-001, 9.963548e-004
14914, -2.135043e-001, 3.818290e-001, 9.963548e-004
14915, -2.130348e-001, 3.809476e-001, 9.963548e-004
14916, -2.125653e-001, 3.800662e-001, 9.963548e-004
14917, -2.120958e-001, 3.791848e-001, 9.963548e-004
14918, -2.116263e-001, 3.783034e-001, 9.963548e-004
14919, -2.111569e-001, 3.774220e-001, 9.963548e-004
14920, -2.106874e-001, 3.765407e-001, 9.963548e-004
14921, -2.102179e-001, 3.756593e-001, 9.963548e-004
14922, -2.097484e-001, 3.747779e-001, 9.963548e-004
14923, -2.092789e-001, 3.738965e-001, 9.963548e-004
14924, -2.088095e-001, 3.730151e-001, 9.963548e-004
14925, -2.083400e-001, 3.721337e-001, 9.963548e-004
14926, -2.078705e-001, 3.712523e-001, 9.963548e-004
14927, -2.074010e-001, 3.703710e-001, 9.963548e-004
14928, -2.069315e-001, 3.694896e-001, 9.963548e-004
14929, -2.064620e-001, 3.686082e-001, 9.963548e-004
14930, -2.059926e-001, 3.677268e-001, 9.963548e-004
14931, -2.055231e-001, 3.668454e-001, 9.963548e-004
14932, -2.050536e-001, 3.659640e-001, 9.963548e-004
14933, -2.045841e-001, 3.650827e-001, 9.963548e-004
14934, -2.041146e-001, 3.642013e-001, 9.963548e-004
14935, -2.036451e-001, 3.633199e-001, 9.963548e-004
14936, -2.031757e-001, 3.624385e-001, 9.963548e-004
14937, -2.027062e-001, 3.615571e-001, 9.963548e-004
14938, -2.022367e-001, 3.606757e-001, 9.963548e-004
14939, -2.017672e-001, 3.597944e-001, 9.963548e-004
14940, -2.012977e-001, 3.589130e-001, 9.963548e-004
14941, -2.008283e-001, 3.580316e-001, 9.963548e-004
14942, -2.003588e-001, 3.571502e-001, 9.963548e-004
14943, -1.998893e-001, 3.562688e-001, 9.963548e-004
14944, -1.994198e-001, 3.553874e-001, 9.963548e-004
14945, -1.989503e-001, 3.545061e-001, 9.963548e-004
14946, -1.984808e-001, 3.536247e-001, 9.963548e-004
14947, -1.980114e-001, 3.527433e-001, 9.963548e-004
14948, -1.975419e-001, 3.518619e-001, 9.963548e-004
14949, -1.970724e-001, 3.509805e-001, 9.963548e-004
14950, -1.966029e-001, 3.500991e-001, 9.963548e-004
14951, -1.961334e-001, 3.492178e-001, 9.963548e-004
14952, -1.956639e-001, 3.483364e-001, 9.963548e-004
14953, -1.951945e-001, 3.474550e-001, 9.963548e-004
14954, -1.947250e-001, 3.465736e-001, 9.963548e-004
14955, -1.942555e-001, 3.456922e-001, 9.963548e-004
14956, -1.937860e-001, 3.448108e-001, 9.963548e-004
14957, -1.933165e-001, 3.439294e-001, 9.963548e-004
14958, -1.928471e-001, 3.430481e-001, 9.963548e-004
14959, -1.923776e-001, 3.421667e-001, 9.963548e-004
14960, -1.919081e-001, 3.412853e-001, 9.963548e-004
14961, -1.914386e-001, 3.404039e-001, 9.963548e-004
14962, -1.909691e-001, 3.395225e-001, 9.963548e-004
14963, -1.904996e-001, 3.386411e-001, 9.963548e-004
14964, -1.900302e-001, 3.377598e-001, 9.963548e-004
14965, -1.895607e-001, 3.368784e-001, 9.963548e-004
14966, -1.890912e-001, 3.359970e-001, 9.963548e-004
14967, -1.886217e-001, 3.351156e-001, 9.963548e-004
14968, -1.881522e-001, 3.342342e-001, 9.963548e-004
14969, -1.876827e-001, 3.333528e-001, 9.963548e-004
14970, -1.872133e-001, 3.324715e-001, 9.963548e-004
14971, -1.867438e-001, 3.315901e-001, 9.963548e-004
14972, -1.862743e-001, 3.307087e-001, 9.963548e-004
14973, -1.858048e-001, 3.298273e-001, 9.963548e-004
14974, -1.853353e-001, 3.289459e-001, 9.963548e-004
14975, -1.848658e-001, 3.280645e-001, 9.963548e-004
14976, -1.843964e-001, 3.271832e-001, 9.963548e-004
14977, -1.839269e-001, 3.263018e-001, 9.963548e-004
14978, -1.834574e-001, 3.254204e-001, 9.963548e-004
14979, -1.829879e-001, 3.245390e-001, 9.963548e-004
14980, -1.825184e-001, 3.236576e-001, 9.963548e-004
14981, -1.820490e-001, 3.227762e-001, 9.963548e-004
14982, -1.815795e-001, 3.218949e-001, 9.963548e-004
14983, -1.811100e-001, 3.210135e-001, 9.963548e-004
14984, -1.806405e-001, 3.201321e-001, 9.963548e-004
14985, -1.801710e-001, 3.192507e-001, 9.963548e-004
14986, -1.797015e-001, 3.183693e-001, 9.963548e-004
14987, -1.792321e-001, 3.174879e-001, 9.963548e-004
14988, -1.787626e-001, 3.166065e-001, 9.963548e-004
14989, -1.782931e-001, 3.157252e-001, 9.963548e-004
14990, -1.778236e-001, 3.148438e-001, 9.963548e-004
14991, -1.773541e-001, 3.139624e-001, 9.963548e-004
14992, -1.768846e-001, 3.130810e-001, 9.963548e-004
14993, -1.764152e-001, 3.121996e-001, 9.963548e-004
14994, -1.759457e-001, 3.113182e-001, 9.963548e-004
14995, -1.754762e-001, 3.104369e-001, 9.963548e-004
14996, -1.750067e-001, 3.095555e-001, 9.963548e-004
14997, -1.745372e-001, 3.086741e-001, 9.963548e-004
14998, -1.740678e-001, 3.077927e-001, 9.963548e-004
14999, -1.735983e-001, 3.069113e-001, 9.963548e-004
15000, -1.731288e-001, 3.060299e-001, 9.963548e-004
15001, -1.726593e-001, 3.051486e-001, 9.963548e-004
15002, -1.721898e-001, 3.042672e-001, 9.963548e-004
15003, -1.717203e-001, 3.033858e-001, 9.963548e-004
15004, -1.712509e-001, 3.025044e-001, 9.963548e-004
15005, -1.707814e-001, 3.016230e-001, 9.963548e-004
15006, -1.703119e-001, 3.007416e-001, 9.963548e-004
15007, -1.698424e-001, 2.998603e-001, 9.963548e-004
15008, -1.693729e-001, 2.989789e-001, 9.963548e-004
15009, -1.689034e-001, 2.980975e-001, 9.963548e-004
15010, -1.684340e-001, 2.972161e-001, 9.963548e-004
15011, -1.679645e-001, 2.963347e-001, 9.963548e-004
15012, -1.674950e-001, 2.954533e-001, 9.963548e-004
15013, -1.670255e-001, 2.945720e-001, 9.963548e-004
15014, -1.665560e-001, 2.936906e-001, 9.963548e-004
15015, -1.660866e-001, 2.928092e-001, 9.963548e-004
15016, -1.656171e-001, 2.919278e-001, 9.963548e-004
15017, -1.651476e-001, 2.910464e-001, 9.963548e-004
15018, -1.646781e-001, 2.901650e-001, 9.963548e-004
15019, -1.642086e-001, 2.892836e-001, 9.963548e-004
15020, -1.637391e-001, 2.884023e-001, 9.963548e-004
15021, -1.632697e-001, 2.875209e-001, 9.963548e-004
15022, -1.628002e-001, 2.866395e-001, 9.963548e-004
15023, -1.623307e-001, 2.857581e-001, 9.963548e-004
15024, -1.618612e-001, 2.848767e-001, 9.963548e-004
15025, -1.613917e-001, 2.839953e-001, 9.963548e-004
15026, -1.609222e-001, 2.831140e-001, 9.963548e-004
15027, -1.604528e-001, 2.822326e-001, 9.963548e-004
15028, -1.599833e-001, 2.813512e-001, 9.963548e-004
15029, -1.595138e-001, 2.804698e-001, 9.963548e-004
15030, -1.590443e-001, 2.795884e-001, 9.963548e-004
15031, -1.585748e-001, 2.787070e-001, 9.963548e-004
15032, -1.581054e-001, 2.778257e-001, 9.963548e-004
15033, -1.576359e-001, 2.769443e-001, 9.963548e-004
15034, -1.571664e-001, 2.760629e-001, 9.963548e-004
15035, -1.566969e-001, 2.751815e-001, 9.963548e-004
15036, -1.562274e-001, 2.743001e-001, 9.963548e-004
15037, -1.557579e-001, 2.734187e-001, 9.963548e-004
15038, -1.552885e-001, 2.725374e-001, 9.963548e-004
15039, -1.548190e-001, 2.716560e-001, 9.963548e-004
15040, -1.543495e-001, 2.707746e-001, 9.963548e-004
15041, -1.538800e-001, 2.698932e-001, 9.963548e-004
15042, -1.534105e-001, 2.690118e-001, 9.963548e-004
15043, -1.529410e-001, 2.681304e-001, 9.963548e-004
15044, -1.524716e-001, 2.672491e-001, 9.963548e-004
15045, -1.520021e-001, 2.663677e-001, 9.963548e-004
15046, -1.515326e-001, 2.654863e-001, 9.963548e-004
15047, -1.510631e-001, 2.646049e-001, 9.963548e-004
15048, -1.505936e-001, 2.637235e-001, 9.963548e-004
15049, -1.501242e-001, 2.628421e-001, 9.963548e-004
15050, -1.496547e-001, 2.619608e-001, 9.963453e-004
15051, -1.491847e-001, 2.610787e-001, 9.972801e-004
15052, -1.487130e-001, 2.601951e-001, 1.003180e-003
15053, -1.482393e-001, 2.593114e-001, 1.021574e-003
15054, -1.477628e-001, 2.584287e-001, 1.058908e-003
15055, -1.472798e-001, 2.575390e-001, 1.109499e-003
15056, -1.467964e-001, 2.566330e-001, 1.114489e-003
15057, -1.366333e-001, 2.385218e-001, 2.706874e-003
15058, -1.364011e-001, 2.393415e-001, 3.821107e-003
15059, -1.365864e-001, 2.407545e-001, 4.497045e-003
15060, -1.368323e-001, 2.420268e-001, 4.916035e-003
15061, -1.371777e-001, 2.432364e-001, 5.169833e-003
15062, -1.376035e-001, 2.443802e-001, 5.313075e-003
15063, -1.380913e-001, 2.454618e-001, 5.379002e-003
15064, -1.386252e-001, 2.464884e-001, 5.388505e-003
15065, -1.391934e-001, 2.474682e-001, 5.354335e-003
15066, -1.397887e-001, 2.484097e-001, 5.283525e-003
15067, -1.404063e-001, 2.493199e-001, 5.179305e-003
15068, -1.410437e-001, 2.502041e-001, 5.041888e-003
15069, -1.416997e-001, 2.510663e-001, 4.868683e-003
15070, -1.423752e-001, 2.519093e-001, 4.653396e-003
15071, -1.430728e-001, 2.527351e-001, 4.384457e-003
15072, -1.437926e-001, 2.535438e-001, 4.046430e-003
15073, -1.445198e-001, 2.543225e-001, 3.625911e-003
15074, -1.452020e-001, 2.550226e-001, 3.131244e-003
15075, -1.457613e-001, 2.555805e-001, 2.617973e-003
15076, -1.464415e-001, 2.561489e-001, 1.554926e-003
15077, -1.460559e-001, 2.555530e-001, 1.799018e-003
15078, -1.251268e-001, 2.449376e-001, 1.972167e-003
15079, -1.254348e-001, 2.447735e-001, 2.907949e-003
15080, -1.258573e-001, 2.445485e-001, 3.784519e-003
15081, -1.263855e-001, 2.442671e-001, 4.584042e-003
15082, -1.270089e-001, 2.439351e-001, 5.290255e-003
15083, -1.277145e-001, 2.435592e-001, 5.888779e-003
15084, -1.284882e-001, 2.431470e-001, 6.367446e-003
15085, -1.293147e-001, 2.427072e-001, 6.716600e-003
15086, -1.301771e-001, 2.422498e-001, 6.928864e-003
15087, -1.310583e-001, 2.417840e-001, 7.000000e-003
15088, -1.319387e-001, 2.413127e-001, 6.928211e-003
15089, -1.327887e-001, 2.408321e-001, 6.715301e-003
15090, -1.335761e-001, 2.403577e-001, 6.373757e-003
15091, -1.343228e-001, 2.399747e-001, 5.921436e-003
15092, -1.349460e-001, 2.395254e-001, 5.366601e-003
15093, -1.356386e-001, 2.395067e-001, 4.779366e-003
15094, -1.255977e-001, 2.458217e-001, 1.972199e-003
15095, -1.260687e-001, 2.467058e-001, 1.972239e-003
15096, -1.265397e-001, 2.475900e-001, 1.972284e-003
15097, -1.270106e-001, 2.484741e-001, 1.972336e-003
15098, -1.274816e-001, 2.493582e-001, 1.972384e-003
15099, -1.279526e-001, 2.502424e-001, 1.972417e-003
15100, -1.284235e-001, 2.511265e-001, 1.972434e-003
15101, -1.288945e-001, 2.520107e-001, 1.972442e-003
15102, -1.293654e-001, 2.528948e-001, 1.972444e-003
15103, -1.298364e-001, 2.537790e-001, 1.972446e-003
15104, -1.303073e-001, 2.546631e-001, 1.972446e-003
15105, -1.307783e-001, 2.555472e-001, 1.972446e-003
15106, -1.312492e-001, 2.564314e-001, 1.972446e-003
15107, -1.317202e-001, 2.573155e-001, 1.972446e-003
15108, -1.321911e-001, 2.581997e-001, 1.972446e-003
15109, -1.326621e-001, 2.590838e-001, 1.972446e-003
15110, -1.331330e-001, 2.599679e-001, 1.972446e-003
15111, -1.336040e-001, 2.608521e-001, 1.972446e-003
15112, -1.340749e-001, 2.617362e-001, 1.972446e-003
15113, -1.345459e-001, 2.626204e-001, 1.972446e-003
15114, -1.350168e-001, 2.635045e-001, 1.972446e-003
15115, -1.354878e-001, 2.643887e-001, 1.972446e-003
15116, -1.359587e-001, 2.652728e-001, 1.972446e-003
15117, -1.364297e-001, 2.661569e-001, 1.972446e-003
15118, -1.369006e-001, 2.670411e-001, 1.972446e-003
15119, -1.373716e-001, 2.679252e-001, 1.972446e-003
15120, -1.378425e-001, 2.688094e-001, 1.972446e-003
15121, -1.383135e-001, 2.696935e-001, 1.972446e-003
15122, -1.387844e-001, 2.705776e-001, 1.972446e-003
15123, -1.392554e-001, 2.714618e-001, 1.972446e-003
15124, -1.397263e-001, 2.723459e-001, 1.972446e-003
15125, -1.401973e-001, 2.732301e-001, 1.972446e-003
15126, -1.406682e-001, 2.741142e-001, 1.972446e-003
15127, -1.411392e-001, 2.749983e-001, 1.972446e-003
15128, -1.416102e-001, 2.758825e-001, 1.972446e-003
15129, -1.420811e-001, 2.767666e-001, 1.972446e-003
15130, -1.425521e-001, 2.776508e-001, 1.972446e-003
15131, -1.430230e-001, 2.785349e-001, 1.972446e-003
15132, -1.434940e-001, 2.794191e-001, 1.972446e-003
15133, -1.439649e-001, 2.803032e-001, 1.972446e-003
15134, -1.444359e-001, 2.811873e-001, 1.972446e-003
15135, -1.449068e-001, 2.820715e-001, 1.972446e-003
15136, -1.453778e-001, 2.829556e-001, 1.972446e-003
15137, -1.458487e-001, 2.838398e-001, 1.972446e-003
15138, -1.463197e-001, 2.847239e-001, 1.972446e-003
15139, -1.467906e-001, 2.856080e-001, 1.972446e-003
15140, -1.472616e-001, 2.864922e-001, 1.972446e-003
15141, -1.477325e-001, 2.873763e-001, 1.972446e-003
15142, -1.482035e-001, 2.882605e-001, 1.972446e-003
15143, -1.486744e-001, 2.891446e-001, 1.972446e-003
15144, -1.491454e-001, 2.900288e-001, 1.972446e-003
15145, -1.496163e-001, 2.909129e-001, 1.972446e-003
15146, -1.500873e-001, 2.917970e-001, 1.972446e-003
15147, -1.505582e-001, 2.926812e-001, 1.972446e-003
15148, -1.510292e-001, 2.935653e-001, 1.972446e-003
15149, -1.515001e-001, 2.944495e-001, 1.972446e-003
15150, -1.519711e-001, 2.953336e-001, 1.972446e-003
15151, -1.524420e-001, 2.962177e-001, 1.972446e-003
15152, -1.529130e-001, 2.971019e-001, 1.972446e-003
15153, -1.533839e-001, 2.979860e-001, 1.972446e-003
15154, -1.538549e-001, 2.988702e-001, 1.972446e-003
15155, -1.543258e-001, 2.997543e-001, 1.972446e-003
15156, -1.547968e-001, 3.006385e-001, 1.972446e-003
15157, -1.552677e-001, 3.015226e-001, 1.972446e-003
15158, -1.557387e-001, 3.024067e-001, 1.972446e-003
15159, -1.562096e-001, 3.032909e-001, 1.972446e-003
15160, -1.566806e-001, 3.041750e-001, 1.972446e-003
15161, -1.571515e-001, 3.050592e-001, 1.972446e-003
15162, -1.576225e-001, 3.059433e-001, 1.972446e-003
15163, -1.580934e-001, 3.068274e-001, 1.972446e-003
15164, -1.585644e-001, 3.077116e-001, 1.972446e-003
15165, -1.590354e-001, 3.085957e-001, 1.972446e-003
15166, -1.595063e-001, 3.094799e-001, 1.972446e-003
15167, -1.599773e-001, 3.103640e-001, 1.972446e-003
15168, -1.604482e-001, 3.112481e-001, 1.972446e-003
15169, -1.609192e-001, 3.121323e-001, 1.972446e-003
15170, -1.613901e-001, 3.130164e-001, 1.972446e-003
15171, -1.618611e-001, 3.139006e-001, 1.972446e-003
15172, -1.623320e-001, 3.147847e-001, 1.972446e-003
15173, -1.628030e-001, 3.156689e-001, 1.972446e-003
15174, -1.632739e-001, 3.165530e-001, 1.972446e-003
15175, -1.637449e-001, 3.174371e-001, 1.972446e-003
15176, -1.642158e-001, 3.183213e-001, 1.972446e-003
15177, -1.646868e-001, 3.192054e-001, 1.972446e-003
15178, -1.651577e-001, 3.200896e-001, 1.972446e-003
15179, -1.656287e-001, 3.209737e-001, 1.972446e-003
15180, -1.660996e-001, 3.218578e-001, 1.972446e-003
15181, -1.665706e-001, 3.227420e-001, 1.972446e-003
15182, -1.670415e-001, 3.236261e-001, 1.972446e-003
15183, -1.675125e-001, 3.245103e-001, 1.972446e-003
15184, -1.679834e-001, 3.253944e-001, 1.972446e-003
15185, -1.684544e-001, 3.262786e-001, 1.972446e-003
15186, -1.689253e-001, 3.271627e-001, 1.972446e-003
15187, -1.693963e-001, 3.280468e-001, 1.972446e-003
15188, -1.698672e-001, 3.289310e-001, 1.972446e-003
15189, -1.703382e-001, 3.298151e-001, 1.972446e-003
15190, -1.708091e-001, 3.306993e-001, 1.972446e-003
15191, -1.712801e-001, 3.315834e-001, 1.972446e-003
15192, -1.717510e-001, 3.324675e-001, 1.972446e-003
15193, -1.722220e-001, 3.333517e-001, 1.972446e-003
15194, -1.726929e-001, 3.342358e-001, 1.972446e-003
15195, -1.731639e-001, 3.351200e-001, 1.972446e-003
15196, -1.736348e-001, 3.360041e-001, 1.972446e-003
15197, -1.741058e-001, 3.368883e-001, 1.972446e-003
15198, -1.745767e-001, 3.377724e-001, 1.972446e-003
15199, -1.750477e-001, 3.386565e-001, 1.972446e-003
15200, -1.755186e-001, 3.395407e-001, 1.972446e-003
15201, -1.759896e-001, 3.404248e-001, 1.972446e-003
15202, -1.764605e-001, 3.413090e-001, 1.972446e-003
15203, -1.769315e-001, 3.421931e-001, 1.972446e-003
15204, -1.774025e-001, 3.430772e-001, 1.972446e-003
15205, -1.778734e-001, 3.439614e-001, 1.972446e-003
15206, -1.783444e-001, 3.448455e-001, 1.972446e-003
15207, -1.788153e-001, 3.457297e-001, 1.972446e-003
15208, -1.792863e-001, 3.466138e-001, 1.972446e-003
15209, -1.797572e-001, 3.474980e-001, 1.972446e-003
15210, -1.802282e-001, 3.483821e-001, 1.972446e-003
15211, -1.806991e-001, 3.492662e-001, 1.972446e-003
15212, -1.811701e-001, 3.501504e-001, 1.972446e-003
15213, -1.816410e-001, 3.510345e-001, 1.972446e-003
15214, -1.821120e-001, 3.519187e-001, 1.972446e-003
15215, -1.825829e-001, 3.528028e-001, 1.972446e-003
15216, -1.830539e-001, 3.536869e-001, 1.972446e-003
15217, -1.835248e-001, 3.545711e-001, 1.972446e-003
15218, -1.839958e-001, 3.554552e-001, 1.972446e-003
15219, -1.844667e-001, 3.563394e-001, 1.972446e-003
15220, -1.849377e-001, 3.572235e-001, 1.972446e-003
15221, -1.854086e-001, 3.581076e-001, 1.972446e-003
15222, -1.858796e-001, 3.589918e-001, 1.972446e-003
15223, -1.863505e-001, 3.598759e-001, 1.972446e-003
15224, -1.868215e-001, 3.607601e-001, 1.972446e-003
15225, -1.872924e-001, 3.616442e-001, 1.972446e-003
15226, -1.877634e-001, 3.625284e-001, 1.972446e-003
15227, -1.882343e-001, 3.634125e-001, 1.972446e-003
15228, -1.887053e-001, 3.642966e-001, 1.972446e-003
15229, -1.891762e-001, 3.651808e-001, 1.972446e-003
15230, -1.896472e-001, 3.660649e-001, 1.972446e-003
15231, -1.901181e-001, 3.669491e-001, 1.972446e-003
15232, -1.905891e-001, 3.678332e-001, 1.972446e-003
15233, -1.910600e-001, 3.687173e-001, 1.972446e-003
15234, -1.915310e-001, 3.696015e-001, 1.972446e-003
15235, -1.920019e-001, 3.704856e-001, 1.972446e-003
15236, -1.924729e-001, 3.713698e-001, 1.972446e-003
15237, -1.929438e-001, 3.722539e-001, 1.972446e-003
15238, -1.934148e-001, 3.731381e-001, 1.972446e-003
15239, -1.938857e-001, 3.740222e-001, 1.972446e-003
15240, -1.943567e-001, 3.749063e-001, 1.972446e-003
15241, -1.948277e-001, 3.757905e-001, 1.972446e-003
15242, -1.952986e-001, 3.766746e-001, 1.972446e-003
15243, -1.957696e-001, 3.775588e-001, 1.972446e-003
15244, -1.962405e-001, 3.784429e-001, 1.972446e-003
15245, -1.967115e-001, 3.793270e-001, 1.972446e-003
15246, -1.971824e-001, 3.802112e-001, 1.972446e-003
15247, -1.976534e-001, 3.810953e-001, 1.972446e-003
15248, -1.981243e-001, 3.819795e-001, 1.972446e-003
15249, -1.985953e-001, 3.828636e-001, 1.972446e-003
15250, -1.990662e-001, 3.837478e-001, 1.972446e-003
15251, -1.995372e-001, 3.846319e-001, 1.972446e-003
15252, -2.000081e-001, 3.855160e-001, 1.972446e-003
15253, -2.004791e-001, 3.864002e-001, 1.972446e-003
15254, -2.009500e-001, 3.872843e-001, 1.972446e-003
15255, -2.014210e-001, 3.881685e-001, 1.972446e-003
15256, -2.018919e-001, 3.890526e-001, 1.972446e-003
15257, -2.023629e-001, 3.899367e-001, 1.972446e-003
15258, -2.028338e-001, 3.908209e-001, 1.972446e-003
15259, -2.033048e-001, 3.917050e-001, 1.972446e-003
15260, -2.037757e-001, 3.925892e-001, 1.972446e-003
15261, -2.042467e-001, 3.934733e-001, 1.972446e-003
15262, -2.047176e-001, 3.943575e-001, 1.972446e-003
15263, -2.051886e-001, 3.952416e-001, 1.972446e-003
15264, -2.056595e-001, 3.961257e-001, 1.972446e-003
15265, -2.061305e-001, 3.970099e-001, 1.972446e-003
15266, -2.066014e-001, 3.978940e-001, 1.972446e-003
15267, -2.070724e-001, 3.987782e-001, 1.972446e-003
15268, -2.075433e-001, 3.996623e-001, 1.972446e-003
15269, -2.080143e-001, 4.005464e-001, 1.972446e-003
15270, -2.084852e-001, 4.014306e-001, 1.972446e-003
15271, -2.089562e-001, 4.023147e-001, 1.972446e-003
15272, -2.094271e-001, 4.031989e-001, 1.972446e-003
15273, -2.098981e-001, 4.040830e-001, 1.972446e-003
15274, -2.103690e-001, 4.049671e-001, 1.972446e-003
15275, -2.108400e-001, 4.058513e-001, 1.972446e-003
15276, -2.113109e-001, 4.067354e-001, 1.972444e-003
15277, -2.117819e-001, 4.076196e-001, 1.972428e-003
15278, -2.122529e-001, 4.085038e-001, 1.972388e-003
15279, -2.127238e-001, 4.093880e-001, 1.972327e-003
15280, -2.131948e-001, 4.102721e-001, 1.972262e-003
15281, -2.136657e-001, 4.111562e-001, 1.972207e-003
15282, -2.139738e-001, 4.109922e-001, 2.908003e-003
15283, -2.143963e-001, 4.107674e-001, 3.784578e-003
15284, -2.149247e-001, 4.104862e-001, 4.584090e-003
15285, -2.155481e-001, 4.101544e-001, 5.290285e-003
15286, -2.162539e-001, 4.097787e-001, 5.888796e-003
15287, -2.170276e-001, 4.093667e-001, 6.367434e-003
15288, -2.178536e-001, 4.089269e-001, 6.716454e-003
15289, -2.187150e-001, 4.084682e-001, 6.928751e-003
15290, -2.195942e-001, 4.079999e-001, 7.000000e-003
15291, -2.204735e-001, 4.075316e-001, 6.928751e-003
15292, -2.213348e-001, 4.070727e-001, 6.716452e-003
15293, -2.221607e-001, 4.066327e-001, 6.367427e-003
15294, -2.229343e-001, 4.062205e-001, 5.888779e-003
15295, -2.236400e-001, 4.058446e-001, 5.290254e-003
15296, -2.242633e-001, 4.055126e-001, 4.584039e-003
15297, -2.247918e-001, 4.052317e-001, 3.784510e-003
15298, -2.252147e-001, 4.050074e-001, 2.907934e-003
15299, -2.255232e-001, 4.048443e-001, 1.972153e-003
15300, -2.250534e-001, 4.039622e-001, 1.972182e-003
15301, -2.245837e-001, 4.030804e-001, 1.972226e-003
15302, -2.241141e-001, 4.021989e-001, 1.972279e-003
15303, -2.236446e-001, 4.013175e-001, 1.972338e-003
15304, -2.231751e-001, 4.004362e-001, 1.972390e-003
15305, -2.227057e-001, 3.995549e-001, 1.972427e-003
15306, -2.222362e-001, 3.986736e-001, 1.972447e-003
15307, -2.217667e-001, 3.977922e-001, 1.972456e-003
15308, -2.212973e-001, 3.969109e-001, 1.972460e-003
15309, -2.208278e-001, 3.960295e-001, 1.972461e-003
15310, -2.203583e-001, 3.951481e-001, 1.972462e-003
15311, -2.198888e-001, 3.942667e-001, 1.972462e-003
15312, -2.194193e-001, 3.933853e-001, 1.972462e-003
15313, -2.189498e-001, 3.925039e-001, 1.972462e-003
15314, -2.184804e-001, 3.916226e-001, 1.972462e-003
15315, -2.180109e-001, 3.907412e-001, 1.972462e-003
15316, -2.175414e-001, 3.898598e-001, 1.972462e-003
15317, -2.170719e-001, 3.889784e-001, 1.972462e-003
15318, -2.166024e-001, 3.880970e-001, 1.972462e-003
15319, -2.161330e-001, 3.872156e-001, 1.972462e-003
15320, -2.156635e-001, 3.863343e-001, 1.972462e-003
15321, -2.151940e-001, 3.854529e-001, 1.972462e-003
15322, -2.147245e-001, 3.845715e-001, 1.972462e-003
15323, -2.142550e-001, 3.836901e-001, 1.972462e-003
15324, -2.137855e-001, 3.828087e-001, 1.972462e-003
15325, -2.133161e-001, 3.819273e-001, 1.972462e-003
15326, -2.128466e-001, 3.810460e-001, 1.972462e-003
15327, -2.123771e-001, 3.801646e-001, 1.972462e-003
15328, -2.119076e-001, 3.792832e-001, 1.972462e-003
15329, -2.114381e-001, 3.784018e-001, 1.972462e-003
15330, -2.109686e-001, 3.775204e-001, 1.972462e-003
15331, -2.104992e-001, 3.766390e-001, 1.972462e-003
15332, -2.100297e-001, 3.757576e-001, 1.972462e-003
15333, -2.095602e-001, 3.748763e-001, 1.972462e-003
15334, -2.090907e-001, 3.739949e-001, 1.972462e-003
15335, -2.086212e-001, 3.731135e-001, 1.972462e-003
15336, -2.081517e-001, 3.722321e-001, 1.972462e-003
15337, -2.076823e-001, 3.713507e-001, 1.972462e-003
15338, -2.072128e-001, 3.704693e-001, 1.972462e-003
15339, -2.067433e-001, 3.695880e-001, 1.972462e-003
15340, -2.062738e-001, 3.687066e-001, 1.972462e-003
15341, -2.058043e-001, 3.678252e-001, 1.972462e-003
15342, -2.053349e-001, 3.669438e-001, 1.972462e-003
15343, -2.048654e-001, 3.660624e-001, 1.972462e-003
15344, -2.043959e-001, 3.651810e-001, 1.972462e-003
15345, -2.039264e-001, 3.642997e-001, 1.972462e-003
15346, -2.034569e-001, 3.634183e-001, 1.972462e-003
15347, -2.029874e-001, 3.625369e-001, 1.972462e-003
15348, -2.025180e-001, 3.616555e-001, 1.972462e-003
15349, -2.020485e-001, 3.607741e-001, 1.972462e-003
15350, -2.015790e-001, 3.598927e-001, 1.972462e-003
15351, -2.011095e-001, 3.590114e-001, 1.972462e-003
15352, -2.006400e-001, 3.581300e-001, 1.972462e-003
15353, -2.001705e-001, 3.572486e-001, 1.972462e-003
15354, -1.997011e-001, 3.563672e-001, 1.972462e-003
15355, -1.992316e-001, 3.554858e-001, 1.972462e-003
15356, -1.987621e-001, 3.546044e-001, 1.972462e-003
15357, -1.982926e-001, 3.537231e-001, 1.972462e-003
15358, -1.978231e-001, 3.528417e-001, 1.972462e-003
15359, -1.973537e-001, 3.519603e-001, 1.972462e-003
15360, -1.968842e-001, 3.510789e-001, 1.972462e-003
15361, -1.964147e-001, 3.501975e-001, 1.972462e-003
15362, -1.959452e-001, 3.493161e-001, 1.972462e-003
15363, -1.954757e-001, 3.484347e-001, 1.972462e-003
15364, -1.950062e-001, 3.475534e-001, 1.972462e-003
15365, -1.945368e-001, 3.466720e-001, 1.972462e-003
15366, -1.940673e-001, 3.457906e-001, 1.972462e-003
15367, -1.935978e-001, 3.449092e-001, 1.972462e-003
15368, -1.931283e-001, 3.440278e-001, 1.972462e-003
15369, -1.926588e-001, 3.431464e-001, 1.972462e-003
15370, -1.921893e-001, 3.422651e-001, 1.972462e-003
15371, -1.917199e-001, 3.413837e-001, 1.972462e-003
15372, -1.912504e-001, 3.405023e-001, 1.972462e-003
15373, -1.907809e-001, 3.396209e-001, 1.972462e-003
15374, -1.903114e-001, 3.387395e-001, 1.972462e-003
15375, -1.898419e-001, 3.378581e-001, 1.972462e-003
15376, -1.893725e-001, 3.369768e-001, 1.972462e-003
15377, -1.889030e-001, 3.360954e-001, 1.972462e-003
15378, -1.884335e-001, 3.352140e-001, 1.972462e-003
15379, -1.879640e-001, 3.343326e-001, 1.972462e-003
15380, -1.874945e-001, 3.334512e-001, 1.972462e-003
15381, -1.870250e-001, 3.325698e-001, 1.972462e-003
15382, -1.865556e-001, 3.316885e-001, 1.972462e-003
15383, -1.860861e-001, 3.308071e-001, 1.972462e-003
15384, -1.856166e-001, 3.299257e-001, 1.972462e-003
15385, -1.851471e-001, 3.290443e-001, 1.972462e-003
15386, -1.846776e-001, 3.281629e-001, 1.972462e-003
15387, -1.842081e-001, 3.272815e-001, 1.972462e-003
15388, -1.837387e-001, 3.264002e-001, 1.972462e-003
15389, -1.832692e-001, 3.255188e-001, 1.972462e-003
15390, -1.827997e-001, 3.246374e-001, 1.972462e-003
15391, -1.823302e-001, 3.237560e-001, 1.972462e-003
15392, -1.818607e-001, 3.228746e-001, 1.972462e-003
15393, -1.813913e-001, 3.219932e-001, 1.972462e-003
15394, -1.809218e-001, 3.211118e-001, 1.972462e-003
15395, -1.804523e-001, 3.202305e-001, 1.972462e-003
15396, -1.799828e-001, 3.193491e-001, 1.972462e-003
15397, -1.795133e-001, 3.184677e-001, 1.972462e-003
15398, -1.790438e-001, 3.175863e-001, 1.972462e-003
15399, -1.785744e-001, 3.167049e-001, 1.972462e-003
15400, -1.781049e-001, 3.158235e-001, 1.972462e-003
15401, -1.776354e-001, 3.149422e-001, 1.972462e-003
15402, -1.771659e-001, 3.140608e-001, 1.972462e-003
15403, -1.766964e-001, 3.131794e-001, 1.972462e-003
15404, -1.762269e-001, 3.122980e-001, 1.972462e-003
15405, -1.757575e-001, 3.114166e-001, 1.972462e-003
15406, -1.752880e-001, 3.105352e-001, 1.972462e-003
15407, -1.748185e-001, 3.096539e-001, 1.972462e-003
15408, -1.743490e-001, 3.087725e-001, 1.972462e-003
15409, -1.738795e-001, 3.078911e-001, 1.972462e-003
15410, -1.734101e-001, 3.070097e-001, 1.972462e-003
15411, -1.729406e-001, 3.061283e-001, 1.972462e-003
15412, -1.724711e-001, 3.052469e-001, 1.972462e-003
15413, -1.720016e-001, 3.043656e-001, 1.972462e-003
15414, -1.715321e-001, 3.034842e-001, 1.972462e-003
15415, -1.710626e-001, 3.026028e-001, 1.972462e-003
15416, -1.705932e-001, 3.017214e-001, 1.972462e-003
15417, -1.701237e-001, 3.008400e-001, 1.972462e-003
15418, -1.696542e-001, 2.999586e-001, 1.972462e-003
15419, -1.691847e-001, 2.990773e-001, 1.972462e-003
15420, -1.687152e-001, 2.981959e-001, 1.972462e-003
15421, -1.682457e-001, 2.973145e-001, 1.972462e-003
15422, -1.677763e-001, 2.964331e-001, 1.972462e-003
15423, -1.673068e-001, 2.955517e-001, 1.972462e-003
15424, -1.668373e-001, 2.946703e-001, 1.972462e-003
15425, -1.663678e-001, 2.937889e-001, 1.972462e-003
15426, -1.658983e-001, 2.929076e-001, 1.972462e-003
15427, -1.654288e-001, 2.920262e-001, 1.972462e-003
15428, -1.649594e-001, 2.911448e-001, 1.972462e-003
15429, -1.644899e-001, 2.902634e-001, 1.972462e-003
15430, -1.640204e-001, 2.893820e-001, 1.972462e-003
15431, -1.635509e-001, 2.885006e-001, 1.972462e-003
15432, -1.630814e-001, 2.876193e-001, 1.972462e-003
15433, -1.626120e-001, 2.867379e-001, 1.972462e-003
15434, -1.621425e-001, 2.858565e-001, 1.972462e-003
15435, -1.616730e-001, 2.849751e-001, 1.972462e-003
15436, -1.612035e-001, 2.840937e-001, 1.972462e-003
15437, -1.607340e-001, 2.832123e-001, 1.972462e-003
15438, -1.602645e-001, 2.823310e-001, 1.972462e-003
15439, -1.597951e-001, 2.814496e-001, 1.972462e-003
15440, -1.593256e-001, 2.805682e-001, 1.972462e-003
15441, -1.588561e-001, 2.796868e-001, 1.972462e-003
15442, -1.583866e-001, 2.788054e-001, 1.972462e-003
15443, -1.579171e-001, 2.779240e-001, 1.972462e-003
15444, -1.574476e-001, 2.770427e-001, 1.972462e-003
15445, -1.569782e-001, 2.761613e-001, 1.972462e-003
15446, -1.565087e-001, 2.752799e-001, 1.972462e-003
15447, -1.560392e-001, 2.743985e-001, 1.972462e-003
15448, -1.555697e-001, 2.735171e-001, 1.972462e-003
15449, -1.551002e-001, 2.726357e-001, 1.972462e-003
15450, -1.546308e-001, 2.717544e-001, 1.972462e-003
15451, -1.541613e-001, 2.708730e-001, 1.972462e-003
15452, -1.536918e-001, 2.699916e-001, 1.972462e-003
15453, -1.532223e-001, 2.691102e-001, 1.972462e-003
15454, -1.527528e-001, 2.682288e-001, 1.972462e-003
15455, -1.522833e-001, 2.673474e-001, 1.972462e-003
15456, -1.518139e-001, 2.664660e-001, 1.972462e-003
15457, -1.513444e-001, 2.655847e-001, 1.972462e-003
15458, -1.508749e-001, 2.647033e-001, 1.972462e-003
15459, -1.504054e-001, 2.638219e-001, 1.972462e-003
15460, -1.499359e-001, 2.629405e-001, 1.972462e-003
15461, -1.494664e-001, 2.620590e-001, 1.972554e-003
15462, -1.489959e-001, 2.611768e-001, 1.974255e-003
15463, -1.485225e-001, 2.602940e-001, 1.983662e-003
15464, -1.480432e-001, 2.594136e-001, 2.014348e-003
15465, -1.475498e-001, 2.585355e-001, 2.088280e-003
15466, -1.469910e-001, 2.576102e-001, 2.265787e-003
15467, -1.467164e-001, 2.568561e-001, 1.907035e-003
15468, -1.357295e-001, 2.406050e-001, 5.206980e-003
15469, -1.359777e-001, 2.420318e-001, 5.579918e-003
15470, -1.363512e-001, 2.433689e-001, 5.794255e-003
15471, -1.368001e-001, 2.446087e-001, 5.916478e-003
15472, -1.373181e-001, 2.457700e-001, 5.971664e-003
15473, -1.378845e-001, 2.468596e-001, 5.979247e-003
15474, -1.384858e-001, 2.478906e-001, 5.950954e-003
15475, -1.391173e-001, 2.488747e-001, 5.891247e-003
15476, -1.397745e-001, 2.498191e-001, 5.801674e-003
15477, -1.404547e-001, 2.507308e-001, 5.681963e-003
15478, -1.411584e-001, 2.516161e-001, 5.528799e-003
15479, -1.418887e-001, 2.524799e-001, 5.335139e-003
15480, -1.426510e-001, 2.533259e-001, 5.088701e-003
15481, -1.434515e-001, 2.541558e-001, 4.770022e-003
15482, -1.442869e-001, 2.549562e-001, 4.350144e-003
15483, -1.451094e-001, 2.556677e-001, 3.804832e-003
15484, -1.458127e-001, 2.561979e-001, 3.158089e-003
15485, -1.263768e-001, 2.465417e-001, 2.908042e-003
15486, -1.259058e-001, 2.456576e-001, 2.907986e-003
15487, -1.263283e-001, 2.454326e-001, 3.784554e-003
15488, -1.268565e-001, 2.451512e-001, 4.584064e-003
15489, -1.274798e-001, 2.448191e-001, 5.290271e-003
15490, -1.281855e-001, 2.444432e-001, 5.888831e-003
15491, -1.289599e-001, 2.440314e-001, 6.367705e-003
15492, -1.297877e-001, 2.435940e-001, 6.716754e-003
15493, -1.306514e-001, 2.431426e-001, 6.928693e-003
15494, -1.315365e-001, 2.426870e-001, 7.000000e-003
15495, -1.324275e-001, 2.422277e-001, 6.928043e-003
15496, -1.332814e-001, 2.417314e-001, 6.711740e-003
15497, -1.339944e-001, 2.411694e-001, 6.379380e-003
15498, -1.348032e-001, 2.409989e-001, 5.957339e-003
15499, -1.273187e-001, 2.483100e-001, 2.908209e-003
15500, -1.268477e-001, 2.474259e-001, 2.908112e-003
15501, -1.277897e-001, 2.491941e-001, 2.908305e-003
15502, -1.282607e-001, 2.500782e-001, 2.908375e-003
15503, -1.287317e-001, 2.509624e-001, 2.908425e-003
15504, -1.292026e-001, 2.518465e-001, 2.908427e-003
15505, -1.296736e-001, 2.527306e-001, 2.908420e-003
15506, -1.301445e-001, 2.536148e-001, 2.908441e-003
15507, -1.306155e-001, 2.544989e-001, 2.908452e-003
15508, -1.310865e-001, 2.553831e-001, 2.908446e-003
15509, -1.315574e-001, 2.562672e-001, 2.908454e-003
15510, -1.320284e-001, 2.571514e-001, 2.908474e-003
15511, -1.324994e-001, 2.580356e-001, 2.908468e-003
15512, -1.329703e-001, 2.589197e-001, 2.908426e-003
15513, -1.334412e-001, 2.598038e-001, 2.908412e-003
15514, -1.339122e-001, 2.606879e-001, 2.908419e-003
15515, -1.343831e-001, 2.615721e-001, 2.908426e-003
15516, -1.348541e-001, 2.624562e-001, 2.908429e-003
15517, -1.353250e-001, 2.633404e-001, 2.908430e-003
15518, -1.357960e-001, 2.642245e-001, 2.908431e-003
15519, -1.362669e-001, 2.651086e-001, 2.908431e-003
15520, -1.367379e-001, 2.659928e-001, 2.908431e-003
15521, -1.372088e-001, 2.668769e-001, 2.908431e-003
15522, -1.376798e-001, 2.677611e-001, 2.908431e-003
15523, -1.381507e-001, 2.686452e-001, 2.908431e-003
15524, -1.386217e-001, 2.695293e-001, 2.908431e-003
15525, -1.390926e-001, 2.704135e-001, 2.908431e-003
15526, -1.395636e-001, 2.712976e-001, 2.908431e-003
15527, -1.400345e-001, 2.721818e-001, 2.908431e-003
15528, -1.405055e-001, 2.730659e-001, 2.908431e-003
15529, -1.409764e-001, 2.739501e-001, 2.908431e-003
15530, -1.414474e-001, 2.748342e-001, 2.908431e-003
15531, -1.419183e-001, 2.757183e-001, 2.908431e-003
15532, -1.423893e-001, 2.766025e-001, 2.908431e-003
15533, -1.428602e-001, 2.774866e-001, 2.908431e-003
15534, -1.433312e-001, 2.783708e-001, 2.908431e-003
15535, -1.438021e-001, 2.792549e-001, 2.908431e-003
15536, -1.442731e-001, 2.801390e-001, 2.908431e-003
15537, -1.447440e-001, 2.810232e-001, 2.908431e-003
15538, -1.452150e-001, 2.819073e-001, 2.908431e-003
15539, -1.456859e-001, 2.827915e-001, 2.908431e-003
15540, -1.461569e-001, 2.836756e-001, 2.908431e-003
15541, -1.466278e-001, 2.845597e-001, 2.908431e-003
15542, -1.470988e-001, 2.854439e-001, 2.908431e-003
15543, -1.475697e-001, 2.863280e-001, 2.908431e-003
15544, -1.480407e-001, 2.872122e-001, 2.908431e-003
15545, -1.485117e-001, 2.880963e-001, 2.908431e-003
15546, -1.489826e-001, 2.889805e-001, 2.908431e-003
15547, -1.494536e-001, 2.898646e-001, 2.908431e-003
15548, -1.499245e-001, 2.907487e-001, 2.908431e-003
15549, -1.503955e-001, 2.916329e-001, 2.908431e-003
15550, -1.508664e-001, 2.925170e-001, 2.908431e-003
15551, -1.513374e-001, 2.934012e-001, 2.908431e-003
15552, -1.518083e-001, 2.942853e-001, 2.908431e-003
15553, -1.522793e-001, 2.951694e-001, 2.908431e-003
15554, -1.527502e-001, 2.960536e-001, 2.908431e-003
15555, -1.532212e-001, 2.969377e-001, 2.908431e-003
