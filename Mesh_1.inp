5863, -8.203920e-002, 1.462802e-002, 3.125851e-002
5864, -8.186321e-002, 1.364110e-002, 3.126200e-002
5865, -8.140321e-002, 1.372270e-002, 3.039105e-002
5866, -8.187888e-002, 1.363151e-002, 2.471171e-002
5867, -8.093455e-002, 1.380342e-002, 2.749294e-002
5868, -8.093262e-002, 1.380497e-002, 2.848081e-002
5869, -8.109024e-002, 1.377790e-002, 2.945550e-002
5870, -8.319713e-002, 1.339335e-002, 2.326035e-002
5871, -8.247882e-002, 1.352312e-002, 2.393054e-002
5872, -8.401414e-002, 1.324573e-002, 2.271946e-002
5873, -8.490761e-002, 1.308429e-002, 2.232260e-002
5874, -8.585318e-002, 1.291344e-002, 2.208058e-002
5875, -8.682509e-002, 1.273785e-002, 2.200000e-002
5876, -8.779683e-002, 1.256231e-002, 2.208309e-002
5877, -8.874190e-002, 1.239160e-002, 2.232759e-002
5878, -8.963450e-002, 1.223039e-002, 2.272684e-002
5879, -9.045025e-002, 1.208306e-002, 2.326995e-002
5880, -9.116687e-002, 1.195362e-002, 2.394208e-002
5881, -9.176480e-002, 1.184559e-002, 2.472484e-002
5882, -9.222779e-002, 1.176198e-002, 2.559689e-002
5883, -9.254324e-002, 1.170530e-002, 2.653435e-002
5884, -9.270263e-002, 1.167720e-002, 2.751157e-002
5885, -9.270171e-002, 1.167839e-002, 2.850192e-002
5886, -9.254056e-002, 1.170870e-002, 2.947845e-002
5887, -9.222362e-002, 1.176722e-002, 3.041458e-002
5888, -1.087593e-001, 1.625739e-001, 3.124886e-002
5889, -1.197359e-001, 1.667053e-001, 3.128169e-002
5890, -1.195576e-001, 1.657182e-001, 3.128169e-002
5891, -1.193793e-001, 1.647309e-001, 3.128169e-002
5892, -1.192009e-001, 1.637438e-001, 3.128169e-002
5893, -1.190227e-001, 1.627571e-001, 3.128169e-002
5894, -1.188445e-001, 1.617706e-001, 3.128169e-002
5895, -1.186663e-001, 1.607842e-001, 3.128169e-002
5896, -1.184881e-001, 1.597979e-001, 3.128169e-002
5897, -1.183099e-001, 1.588116e-001, 3.128169e-002
5898, -1.181318e-001, 1.578253e-001, 3.128169e-002
5899, -1.179536e-001, 1.568390e-001, 3.128169e-002
5900, -1.177754e-001, 1.558527e-001, 3.128169e-002
5901, -1.175972e-001, 1.548664e-001, 3.128169e-002
5902, -1.174191e-001, 1.538802e-001, 3.128169e-002
5903, -1.172409e-001, 1.528939e-001, 3.128169e-002
5904, -1.170627e-001, 1.519076e-001, 3.128169e-002
5905, -1.168845e-001, 1.509213e-001, 3.128169e-002
5906, -1.167064e-001, 1.499350e-001, 3.128169e-002
5907, -1.165282e-001, 1.489487e-001, 3.128169e-002
5908, -1.163500e-001, 1.479625e-001, 3.128169e-002
5909, -1.161719e-001, 1.469762e-001, 3.128169e-002
5910, -1.159937e-001, 1.459899e-001, 3.128169e-002
5911, -1.158155e-001, 1.450036e-001, 3.128169e-002
5912, -1.156373e-001, 1.440173e-001, 3.128169e-002
5913, -1.154592e-001, 1.430310e-001, 3.128169e-002
5914, -1.152810e-001, 1.420448e-001, 3.128169e-002
5915, -1.151028e-001, 1.410585e-001, 3.128169e-002
5916, -1.149246e-001, 1.400722e-001, 3.128169e-002
5917, -1.147465e-001, 1.390859e-001, 3.128169e-002
5918, -1.145683e-001, 1.380996e-001, 3.128169e-002
5919, -1.143901e-001, 1.371133e-001, 3.128169e-002
5920, -1.142120e-001, 1.361270e-001, 3.128169e-002
5921, -1.140338e-001, 1.351408e-001, 3.128169e-002
5922, -1.138556e-001, 1.341545e-001, 3.128169e-002
5923, -1.136774e-001, 1.331682e-001, 3.128169e-002
5924, -1.134993e-001, 1.321819e-001, 3.128169e-002
5925, -1.133211e-001, 1.311956e-001, 3.128169e-002
5926, -1.131429e-001, 1.302093e-001, 3.128169e-002
5927, -1.129648e-001, 1.292231e-001, 3.128169e-002
5928, -1.127866e-001, 1.282368e-001, 3.128169e-002
5929, -1.126084e-001, 1.272505e-001, 3.128169e-002
5930, -1.124302e-001, 1.262642e-001, 3.128169e-002
5931, -1.122521e-001, 1.252779e-001, 3.128169e-002
5932, -1.120739e-001, 1.242916e-001, 3.128169e-002
5933, -1.118957e-001, 1.233054e-001, 3.128169e-002
5934, -1.117175e-001, 1.223191e-001, 3.128169e-002
5935, -1.115394e-001, 1.213328e-001, 3.128169e-002
5936, -1.113612e-001, 1.203465e-001, 3.128169e-002
5937, -1.111830e-001, 1.193602e-001, 3.128169e-002
5938, -1.110049e-001, 1.183739e-001, 3.128169e-002
5939, -1.108267e-001, 1.173876e-001, 3.128169e-002
5940, -1.106485e-001, 1.164014e-001, 3.128169e-002
5941, -1.104703e-001, 1.154151e-001, 3.128169e-002
5942, -1.102922e-001, 1.144288e-001, 3.128169e-002
5943, -1.101140e-001, 1.134425e-001, 3.128169e-002
5944, -1.099358e-001, 1.124562e-001, 3.128169e-002
5945, -1.097576e-001, 1.114699e-001, 3.128169e-002
5946, -1.095795e-001, 1.104837e-001, 3.128169e-002
5947, -1.094013e-001, 1.094974e-001, 3.128169e-002
5948, -1.092231e-001, 1.085111e-001, 3.128169e-002
5949, -1.090450e-001, 1.075248e-001, 3.128169e-002
5950, -1.088668e-001, 1.065385e-001, 3.128169e-002
5951, -1.086886e-001, 1.055522e-001, 3.128169e-002
5952, -1.085104e-001, 1.045660e-001, 3.128169e-002
5953, -1.083323e-001, 1.035797e-001, 3.128169e-002
5954, -1.081541e-001, 1.025934e-001, 3.128169e-002
5955, -1.079759e-001, 1.016071e-001, 3.128169e-002
5956, -1.077977e-001, 1.006208e-001, 3.128169e-002
5957, -1.076196e-001, 9.963453e-002, 3.128169e-002
5958, -1.074414e-001, 9.864825e-002, 3.128169e-002
5959, -1.072632e-001, 9.766197e-002, 3.128169e-002
5960, -1.070851e-001, 9.667568e-002, 3.128169e-002
5961, -1.069069e-001, 9.568940e-002, 3.128169e-002
5962, -1.067287e-001, 9.470311e-002, 3.128169e-002
5963, -1.065505e-001, 9.371683e-002, 3.128169e-002
5964, -1.063724e-001, 9.273054e-002, 3.128169e-002
5965, -1.061942e-001, 9.174426e-002, 3.128169e-002
5966, -1.060160e-001, 9.075798e-002, 3.128169e-002
5967, -1.058378e-001, 8.977169e-002, 3.128169e-002
5968, -1.056597e-001, 8.878541e-002, 3.128169e-002
5969, -1.054815e-001, 8.779912e-002, 3.128169e-002
5970, -1.053033e-001, 8.681284e-002, 3.128169e-002
5971, -1.051252e-001, 8.582656e-002, 3.128169e-002
5972, -1.049470e-001, 8.484027e-002, 3.128169e-002
5973, -1.047688e-001, 8.385399e-002, 3.128169e-002
5974, -1.045906e-001, 8.286770e-002, 3.128169e-002
5975, -1.044125e-001, 8.188142e-002, 3.128169e-002
5976, -1.042343e-001, 8.089513e-002, 3.128169e-002
5977, -1.040561e-001, 7.990885e-002, 3.128169e-002
5978, -1.038779e-001, 7.892257e-002, 3.128169e-002
5979, -1.036998e-001, 7.793628e-002, 3.128169e-002
5980, -1.035216e-001, 7.695000e-002, 3.128169e-002
5981, -1.033434e-001, 7.596371e-002, 3.128169e-002
5982, -1.031653e-001, 7.497743e-002, 3.128169e-002
5983, -1.029871e-001, 7.399115e-002, 3.128169e-002
5984, -1.028089e-001, 7.300486e-002, 3.128169e-002
5985, -1.026307e-001, 7.201858e-002, 3.128169e-002
5986, -1.024526e-001, 7.103229e-002, 3.128169e-002
5987, -1.022744e-001, 7.004601e-002, 3.128169e-002
5988, -1.020962e-001, 6.905973e-002, 3.128169e-002
5989, -1.019181e-001, 6.807344e-002, 3.128169e-002
5990, -1.017399e-001, 6.708716e-002, 3.128169e-002
5991, -1.015617e-001, 6.610087e-002, 3.128169e-002
5992, -1.013835e-001, 6.511459e-002, 3.128169e-002
5993, -1.012054e-001, 6.412830e-002, 3.128169e-002
5994, -1.010272e-001, 6.314202e-002, 3.128169e-002
5995, -1.008490e-001, 6.215574e-002, 3.128169e-002
5996, -1.006708e-001, 6.116945e-002, 3.128169e-002
5997, -1.004927e-001, 6.018317e-002, 3.128169e-002
5998, -1.003145e-001, 5.919688e-002, 3.128169e-002
5999, -1.001363e-001, 5.821060e-002, 3.128169e-002
6000, -9.995815e-002, 5.722432e-002, 3.128169e-002
6001, -9.977998e-002, 5.623803e-002, 3.128169e-002
6002, -9.960181e-002, 5.525175e-002, 3.128169e-002
6003, -9.942364e-002, 5.426546e-002, 3.128169e-002
6004, -9.924546e-002, 5.327918e-002, 3.128169e-002
6005, -9.906729e-002, 5.229289e-002, 3.128169e-002
6006, -9.888912e-002, 5.130661e-002, 3.128169e-002
6007, -9.871095e-002, 5.032033e-002, 3.128169e-002
6008, -9.853277e-002, 4.933404e-002, 3.128169e-002
6009, -9.835460e-002, 4.834776e-002, 3.128169e-002
6010, -9.817643e-002, 4.736147e-002, 3.128169e-002
6011, -9.799825e-002, 4.637519e-002, 3.128169e-002
6012, -9.782008e-002, 4.538891e-002, 3.128169e-002
6013, -9.764191e-002, 4.440262e-002, 3.128169e-002
6014, -9.746374e-002, 4.341634e-002, 3.128169e-002
6015, -9.728556e-002, 4.243005e-002, 3.128169e-002
6016, -9.710739e-002, 4.144377e-002, 3.128169e-002
6017, -9.692922e-002, 4.045748e-002, 3.128169e-002
6018, -9.675105e-002, 3.947120e-002, 3.128169e-002
6019, -9.657287e-002, 3.848492e-002, 3.128169e-002
6020, -9.639470e-002, 3.749863e-002, 3.128169e-002
6021, -9.621653e-002, 3.651235e-002, 3.128169e-002
6022, -9.603836e-002, 3.552606e-002, 3.128169e-002
6023, -9.586018e-002, 3.453978e-002, 3.128169e-002
6024, -9.568201e-002, 3.355350e-002, 3.128169e-002
6025, -9.550384e-002, 3.256721e-002, 3.128169e-002
6026, -9.532567e-002, 3.158093e-002, 3.128169e-002
6027, -9.514749e-002, 3.059464e-002, 3.128169e-002
6028, -9.496932e-002, 2.960836e-002, 3.128169e-002
6029, -9.479115e-002, 2.862207e-002, 3.128169e-002
6030, -9.461298e-002, 2.763579e-002, 3.128169e-002
6031, -9.443480e-002, 2.664951e-002, 3.128169e-002
6032, -9.425663e-002, 2.566322e-002, 3.128169e-002
6033, -9.407846e-002, 2.467694e-002, 3.128169e-002
6034, -9.390029e-002, 2.369065e-002, 3.128169e-002
6035, -9.372211e-002, 2.270437e-002, 3.128169e-002
6036, -9.354394e-002, 2.171809e-002, 3.128169e-002
6037, -9.336577e-002, 2.073180e-002, 3.128169e-002
6038, -9.318760e-002, 1.974552e-002, 3.128169e-002
6039, -9.300942e-002, 1.875923e-002, 3.128169e-002
6040, -9.283123e-002, 1.777291e-002, 3.128171e-002
6041, -9.265297e-002, 1.678646e-002, 3.128180e-002
6042, -9.247457e-002, 1.579979e-002, 3.128203e-002
6043, -9.229601e-002, 1.481291e-002, 3.128246e-002
6044, -9.211728e-002, 1.382593e-002, 3.128310e-002
6045, -9.193844e-002, 1.283902e-002, 3.128393e-002
6046, -1.093817e-001, 1.685810e-001, 3.039854e-002
6047, -1.090675e-001, 1.686375e-001, 2.946249e-002
6048, -1.089089e-001, 1.686661e-001, 2.848735e-002
6049, -1.089100e-001, 1.686660e-001, 2.749898e-002
6050, -1.090710e-001, 1.686374e-001, 2.652386e-002
6051, -1.093876e-001, 1.685811e-001, 2.558831e-002
6052, -1.098516e-001, 1.684986e-001, 2.471777e-002
6053, -1.104506e-001, 1.683916e-001, 2.393617e-002
6054, -1.111678e-001, 1.682613e-001, 2.326512e-002
6055, -1.119840e-001, 1.681126e-001, 2.272314e-002
6056, -1.128768e-001, 1.679503e-001, 2.232509e-002
6057, -1.138220e-001, 1.677789e-001, 2.208183e-002
6058, -1.147938e-001, 1.676031e-001, 2.200000e-002
6059, -1.157657e-001, 1.674278e-001, 2.208184e-002
6060, -1.167112e-001, 1.672576e-001, 2.232510e-002
6061, -1.176044e-001, 1.670973e-001, 2.272317e-002
6062, -1.184210e-001, 1.669511e-001, 2.326517e-002
6063, -1.191385e-001, 1.668221e-001, 2.393632e-002
6064, -1.197373e-001, 1.667127e-001, 2.471832e-002
6065, -1.202012e-001, 1.666276e-001, 2.558984e-002
6066, -1.205177e-001, 1.665696e-001, 2.652710e-002
6067, -1.206780e-001, 1.665398e-001, 2.750454e-002
6068, -1.206779e-001, 1.665390e-001, 2.849549e-002
6069, -1.205172e-001, 1.665669e-001, 2.947292e-002
6070, -1.202003e-001, 1.666228e-001, 3.041017e-002
6071, -1.086573e-001, 1.646301e-001, 3.037427e-002
6072, -1.088379e-001, 1.656174e-001, 3.037939e-002
6073, -1.081196e-001, 1.616710e-001, 3.036705e-002
6074, -1.082984e-001, 1.626572e-001, 3.036862e-002
6075, -9.240224e-002, 1.275374e-002, 3.041367e-002
6076, -1.084779e-001, 1.636435e-001, 3.037153e-002
6077, -1.092005e-001, 1.675936e-001, 3.039201e-002
6078, -1.074067e-001, 1.577258e-001, 3.036657e-002
6079, -1.075849e-001, 1.587121e-001, 3.036658e-002
6080, -1.068722e-001, 1.547670e-001, 3.036657e-002
6081, -1.070503e-001, 1.557533e-001, 3.036656e-002
6082, -8.159211e-002, 1.470003e-002, 2.558117e-002
6083, -8.127488e-002, 1.475833e-002, 2.651522e-002
6084, -1.072285e-001, 1.567396e-001, 3.036656e-002
6085, -1.077630e-001, 1.596984e-001, 3.036660e-002
6086, -1.079413e-001, 1.606847e-001, 3.036675e-002
6087, -1.066940e-001, 1.537807e-001, 3.036656e-002
6088, -1.065158e-001, 1.527944e-001, 3.036656e-002
6089, -1.063376e-001, 1.518081e-001, 3.036656e-002
6090, -1.061595e-001, 1.508219e-001, 3.036656e-002
6091, -1.059813e-001, 1.498356e-001, 3.036656e-002
6092, -1.058031e-001, 1.488493e-001, 3.036656e-002
6093, -1.056250e-001, 1.478630e-001, 3.036656e-002
6094, -1.054468e-001, 1.468767e-001, 3.036656e-002
6095, -1.052686e-001, 1.458904e-001, 3.036656e-002
6096, -1.050904e-001, 1.449042e-001, 3.036656e-002
6097, -1.049123e-001, 1.439179e-001, 3.036656e-002
6098, -1.047341e-001, 1.429316e-001, 3.036656e-002
6099, -1.045559e-001, 1.419453e-001, 3.036656e-002
6100, -1.043777e-001, 1.409590e-001, 3.036656e-002
6101, -1.041996e-001, 1.399727e-001, 3.036656e-002
6102, -1.040214e-001, 1.389864e-001, 3.036656e-002
6103, -1.038432e-001, 1.380002e-001, 3.036656e-002
6104, -1.036651e-001, 1.370139e-001, 3.036656e-002
6105, -1.034869e-001, 1.360276e-001, 3.036656e-002
6106, -1.033087e-001, 1.350413e-001, 3.036656e-002
6107, -1.031305e-001, 1.340550e-001, 3.036656e-002
6108, -1.029524e-001, 1.330687e-001, 3.036656e-002
6109, -1.027742e-001, 1.320825e-001, 3.036656e-002
6110, -1.025960e-001, 1.310962e-001, 3.036656e-002
6111, -1.024178e-001, 1.301099e-001, 3.036656e-002
6112, -1.022397e-001, 1.291236e-001, 3.036656e-002
6113, -1.020615e-001, 1.281373e-001, 3.036656e-002
6114, -1.018833e-001, 1.271510e-001, 3.036656e-002
6115, -1.017052e-001, 1.261648e-001, 3.036656e-002
6116, -1.015270e-001, 1.251785e-001, 3.036656e-002
6117, -1.013488e-001, 1.241922e-001, 3.036656e-002
6118, -1.011706e-001, 1.232059e-001, 3.036656e-002
6119, -1.009925e-001, 1.222196e-001, 3.036656e-002
6120, -1.008143e-001, 1.212333e-001, 3.036656e-002
6121, -1.006361e-001, 1.202470e-001, 3.036656e-002
6122, -1.004579e-001, 1.192608e-001, 3.036656e-002
6123, -1.002798e-001, 1.182745e-001, 3.036656e-002
6124, -1.001016e-001, 1.172882e-001, 3.036656e-002
6125, -9.992343e-002, 1.163019e-001, 3.036656e-002
6126, -9.974526e-002, 1.153156e-001, 3.036656e-002
6127, -9.956709e-002, 1.143293e-001, 3.036656e-002
6128, -9.938891e-002, 1.133431e-001, 3.036656e-002
6129, -9.921074e-002, 1.123568e-001, 3.036656e-002
6130, -9.903257e-002, 1.113705e-001, 3.036656e-002
6131, -9.885440e-002, 1.103842e-001, 3.036656e-002
6132, -9.867622e-002, 1.093979e-001, 3.036656e-002
6133, -9.849805e-002, 1.084116e-001, 3.036656e-002
6134, -9.831988e-002, 1.074254e-001, 3.036656e-002
6135, -9.814171e-002, 1.064391e-001, 3.036656e-002
6136, -9.796353e-002, 1.054528e-001, 3.036656e-002
6137, -9.778536e-002, 1.044665e-001, 3.036656e-002
6138, -9.760719e-002, 1.034802e-001, 3.036656e-002
6139, -9.742902e-002, 1.024939e-001, 3.036656e-002
6140, -9.725084e-002, 1.015076e-001, 3.036656e-002
6141, -9.707267e-002, 1.005214e-001, 3.036656e-002
6142, -9.689450e-002, 9.953508e-002, 3.036656e-002
6143, -9.671633e-002, 9.854880e-002, 3.036656e-002
6144, -9.653815e-002, 9.756251e-002, 3.036656e-002
6145, -9.635998e-002, 9.657623e-002, 3.036656e-002
6146, -9.618181e-002, 9.558994e-002, 3.036656e-002
6147, -9.600364e-002, 9.460366e-002, 3.036656e-002
6148, -9.582546e-002, 9.361738e-002, 3.036656e-002
6149, -9.564729e-002, 9.263109e-002, 3.036656e-002
6150, -9.546912e-002, 9.164481e-002, 3.036656e-002
6151, -9.529094e-002, 9.065852e-002, 3.036656e-002
6152, -9.511277e-002, 8.967224e-002, 3.036656e-002
6153, -9.493460e-002, 8.868595e-002, 3.036656e-002
6154, -9.475643e-002, 8.769967e-002, 3.036656e-002
6155, -9.457825e-002, 8.671339e-002, 3.036656e-002
6156, -9.440008e-002, 8.572710e-002, 3.036656e-002
6157, -9.422191e-002, 8.474082e-002, 3.036656e-002
6158, -9.404374e-002, 8.375453e-002, 3.036656e-002
6159, -9.386556e-002, 8.276825e-002, 3.036656e-002
6160, -9.368739e-002, 8.178197e-002, 3.036656e-002
6161, -9.350922e-002, 8.079568e-002, 3.036656e-002
6162, -9.333105e-002, 7.980940e-002, 3.036656e-002
6163, -9.315287e-002, 7.882311e-002, 3.036656e-002
6164, -9.297470e-002, 7.783683e-002, 3.036656e-002
6165, -9.279653e-002, 7.685054e-002, 3.036656e-002
6166, -9.261836e-002, 7.586426e-002, 3.036656e-002
6167, -9.244018e-002, 7.487798e-002, 3.036656e-002
6168, -9.226201e-002, 7.389169e-002, 3.036656e-002
6169, -9.208384e-002, 7.290541e-002, 3.036656e-002
6170, -9.190567e-002, 7.191912e-002, 3.036656e-002
6171, -9.172749e-002, 7.093284e-002, 3.036656e-002
6172, -9.154932e-002, 6.994656e-002, 3.036656e-002
6173, -9.137115e-002, 6.896027e-002, 3.036656e-002
6174, -9.119298e-002, 6.797399e-002, 3.036656e-002
6175, -9.101480e-002, 6.698770e-002, 3.036656e-002
6176, -9.083663e-002, 6.600142e-002, 3.036656e-002
6177, -9.065846e-002, 6.501513e-002, 3.036656e-002
6178, -9.048029e-002, 6.402885e-002, 3.036656e-002
6179, -9.030211e-002, 6.304257e-002, 3.036656e-002
6180, -9.012394e-002, 6.205628e-002, 3.036656e-002
6181, -8.994577e-002, 6.107000e-002, 3.036656e-002
6182, -8.976760e-002, 6.008371e-002, 3.036656e-002
6183, -8.958942e-002, 5.909743e-002, 3.036656e-002
6184, -8.941125e-002, 5.811115e-002, 3.036656e-002
6185, -8.923308e-002, 5.712486e-002, 3.036656e-002
6186, -8.905490e-002, 5.613858e-002, 3.036656e-002
6187, -8.887673e-002, 5.515229e-002, 3.036656e-002
6188, -8.869856e-002, 5.416601e-002, 3.036656e-002
6189, -8.852039e-002, 5.317973e-002, 3.036656e-002
6190, -8.834221e-002, 5.219344e-002, 3.036656e-002
6191, -8.816404e-002, 5.120716e-002, 3.036656e-002
6192, -8.798587e-002, 5.022087e-002, 3.036656e-002
6193, -8.780770e-002, 4.923459e-002, 3.036656e-002
6194, -8.762952e-002, 4.824830e-002, 3.036656e-002
6195, -8.745135e-002, 4.726202e-002, 3.036656e-002
6196, -8.727318e-002, 4.627574e-002, 3.036656e-002
6197, -8.709501e-002, 4.528945e-002, 3.036656e-002
6198, -8.691683e-002, 4.430317e-002, 3.036656e-002
6199, -8.673866e-002, 4.331688e-002, 3.036656e-002
6200, -8.656049e-002, 4.233060e-002, 3.036656e-002
6201, -8.638232e-002, 4.134432e-002, 3.036656e-002
6202, -8.620414e-002, 4.035803e-002, 3.036656e-002
6203, -8.602597e-002, 3.937175e-002, 3.036656e-002
6204, -8.584780e-002, 3.838546e-002, 3.036656e-002
6205, -8.566963e-002, 3.739918e-002, 3.036656e-002
6206, -8.549145e-002, 3.641289e-002, 3.036656e-002
6207, -8.531328e-002, 3.542661e-002, 3.036656e-002
6208, -8.513511e-002, 3.444033e-002, 3.036656e-002
6209, -8.495694e-002, 3.345404e-002, 3.036656e-002
6210, -8.477876e-002, 3.246776e-002, 3.036656e-002
6211, -8.460059e-002, 3.148147e-002, 3.036656e-002
6212, -8.442242e-002, 3.049519e-002, 3.036656e-002
6213, -8.424425e-002, 2.950891e-002, 3.036656e-002
6214, -8.406607e-002, 2.852262e-002, 3.036656e-002
6215, -8.388790e-002, 2.753634e-002, 3.036656e-002
6216, -8.370973e-002, 2.655005e-002, 3.036656e-002
6217, -8.353156e-002, 2.556377e-002, 3.036656e-002
6218, -8.335338e-002, 2.457748e-002, 3.036656e-002
6219, -8.317521e-002, 2.359120e-002, 3.036656e-002
6220, -8.299704e-002, 2.260492e-002, 3.036656e-002
6221, -8.281886e-002, 2.161863e-002, 3.036656e-002
6222, -8.264075e-002, 2.063228e-002, 3.036673e-002
6223, -8.246290e-002, 1.964570e-002, 3.036760e-002
6224, -8.228556e-002, 1.865870e-002, 3.036978e-002
6225, -8.210874e-002, 1.767134e-002, 3.037333e-002
6226, -8.193228e-002, 1.668385e-002, 3.037773e-002
6227, -8.175595e-002, 1.569646e-002, 3.038239e-002
6228, -8.157964e-002, 1.470941e-002, 3.038693e-002
6229, -8.205692e-002, 1.461569e-002, 2.471134e-002
6230, -8.508551e-002, 1.406840e-002, 2.232256e-002
6231, -8.419200e-002, 1.422983e-002, 2.271942e-002
6232, -8.265669e-002, 1.450722e-002, 2.393045e-002
6233, -1.090191e-001, 1.666054e-001, 3.038566e-002
6234, -8.111295e-002, 1.478897e-002, 2.748871e-002
6235, -8.111036e-002, 1.479105e-002, 2.847595e-002
6236, -8.126724e-002, 1.476434e-002, 2.945078e-002
6237, -8.603112e-002, 1.389756e-002, 2.208055e-002
6238, -8.700304e-002, 1.372197e-002, 2.200001e-002
6239, -8.337495e-002, 1.437744e-002, 2.326031e-002
6240, -8.797477e-002, 1.354643e-002, 2.208312e-002
6241, -8.891981e-002, 1.337572e-002, 2.232763e-002
6242, -8.981237e-002, 1.321449e-002, 2.272689e-002
6243, -9.062808e-002, 1.306715e-002, 2.326999e-002
6244, -9.134468e-002, 1.293771e-002, 2.394212e-002
6245, -9.194262e-002, 1.282974e-002, 2.472489e-002
6246, -9.240562e-002, 1.274643e-002, 2.559687e-002
6247, -9.272112e-002, 1.269028e-002, 2.653415e-002
6248, -9.288064e-002, 1.266277e-002, 2.751112e-002
6249, -9.287990e-002, 1.266442e-002, 2.850123e-002
6250, -9.271897e-002, 1.269507e-002, 2.947758e-002
6251, -1.200220e-001, 1.656356e-001, 3.041017e-002
6252, -1.198436e-001, 1.646480e-001, 3.041017e-002
6253, -1.196652e-001, 1.636606e-001, 3.041017e-002
6254, -1.194869e-001, 1.626736e-001, 3.041017e-002
6255, -1.193086e-001, 1.616869e-001, 3.041017e-002
6256, -1.191304e-001, 1.607005e-001, 3.041017e-002
6257, -1.189522e-001, 1.597141e-001, 3.041017e-002
6258, -1.187741e-001, 1.587278e-001, 3.041017e-002
6259, -1.185959e-001, 1.577415e-001, 3.041017e-002
6260, -1.184177e-001, 1.567552e-001, 3.041017e-002
6261, -1.182395e-001, 1.557689e-001, 3.041017e-002
6262, -1.180614e-001, 1.547826e-001, 3.041017e-002
6263, -1.178832e-001, 1.537963e-001, 3.041017e-002
6264, -1.177050e-001, 1.528100e-001, 3.041017e-002
6265, -1.175268e-001, 1.518237e-001, 3.041017e-002
6266, -1.173487e-001, 1.508375e-001, 3.041017e-002
6267, -1.171705e-001, 1.498512e-001, 3.041017e-002
6268, -1.169923e-001, 1.488649e-001, 3.041017e-002
6269, -1.168142e-001, 1.478786e-001, 3.041017e-002
6270, -1.166360e-001, 1.468923e-001, 3.041017e-002
6271, -1.164578e-001, 1.459060e-001, 3.041017e-002
6272, -1.162796e-001, 1.449198e-001, 3.041017e-002
6273, -1.161015e-001, 1.439335e-001, 3.041017e-002
6274, -1.159233e-001, 1.429472e-001, 3.041017e-002
6275, -1.157451e-001, 1.419609e-001, 3.041017e-002
6276, -1.155670e-001, 1.409746e-001, 3.041017e-002
6277, -1.153888e-001, 1.399883e-001, 3.041017e-002
6278, -1.152106e-001, 1.390021e-001, 3.041017e-002
6279, -1.150324e-001, 1.380158e-001, 3.041017e-002
6280, -1.148543e-001, 1.370295e-001, 3.041017e-002
6281, -1.146761e-001, 1.360432e-001, 3.041017e-002
6282, -1.144979e-001, 1.350569e-001, 3.041017e-002
6283, -1.143197e-001, 1.340706e-001, 3.041017e-002
6284, -1.141416e-001, 1.330843e-001, 3.041017e-002
6285, -1.139634e-001, 1.320981e-001, 3.041017e-002
6286, -1.137852e-001, 1.311118e-001, 3.041017e-002
6287, -1.136071e-001, 1.301255e-001, 3.041017e-002
6288, -1.134289e-001, 1.291392e-001, 3.041017e-002
6289, -1.132507e-001, 1.281529e-001, 3.041017e-002
6290, -1.130725e-001, 1.271666e-001, 3.041017e-002
6291, -1.128944e-001, 1.261804e-001, 3.041017e-002
6292, -1.127162e-001, 1.251941e-001, 3.041017e-002
6293, -1.125380e-001, 1.242078e-001, 3.041017e-002
6294, -1.123598e-001, 1.232215e-001, 3.041017e-002
6295, -1.121817e-001, 1.222352e-001, 3.041017e-002
6296, -1.120035e-001, 1.212489e-001, 3.041017e-002
6297, -1.118253e-001, 1.202627e-001, 3.041017e-002
6298, -1.116472e-001, 1.192764e-001, 3.041017e-002
6299, -1.114690e-001, 1.182901e-001, 3.041017e-002
6300, -1.112908e-001, 1.173038e-001, 3.041017e-002
6301, -1.111126e-001, 1.163175e-001, 3.041017e-002
6302, -1.109345e-001, 1.153312e-001, 3.041017e-002
6303, -1.107563e-001, 1.143450e-001, 3.041017e-002
6304, -1.105781e-001, 1.133587e-001, 3.041017e-002
6305, -1.103999e-001, 1.123724e-001, 3.041017e-002
6306, -1.102218e-001, 1.113861e-001, 3.041017e-002
6307, -1.100436e-001, 1.103998e-001, 3.041017e-002
6308, -1.098654e-001, 1.094135e-001, 3.041017e-002
6309, -1.096873e-001, 1.084272e-001, 3.041017e-002
6310, -1.095091e-001, 1.074410e-001, 3.041017e-002
6311, -1.093309e-001, 1.064547e-001, 3.041017e-002
6312, -1.091527e-001, 1.054684e-001, 3.041017e-002
6313, -1.089746e-001, 1.044821e-001, 3.041017e-002
6314, -1.087964e-001, 1.034958e-001, 3.041017e-002
6315, -1.086182e-001, 1.025095e-001, 3.041017e-002
6316, -1.084400e-001, 1.015233e-001, 3.041017e-002
6317, -1.082619e-001, 1.005370e-001, 3.041017e-002
6318, -1.080837e-001, 9.955069e-002, 3.041017e-002
6319, -1.079055e-001, 9.856440e-002, 3.041017e-002
6320, -1.077274e-001, 9.757812e-002, 3.041017e-002
6321, -1.075492e-001, 9.659184e-002, 3.041017e-002
6322, -1.073710e-001, 9.560555e-002, 3.041017e-002
6323, -1.071928e-001, 9.461927e-002, 3.041017e-002
6324, -1.070147e-001, 9.363298e-002, 3.041017e-002
6325, -1.068365e-001, 9.264670e-002, 3.041017e-002
6326, -1.066583e-001, 9.166042e-002, 3.041017e-002
6327, -1.064801e-001, 9.067413e-002, 3.041017e-002
6328, -1.063020e-001, 8.968785e-002, 3.041017e-002
6329, -1.061238e-001, 8.870156e-002, 3.041017e-002
6330, -1.059456e-001, 8.771528e-002, 3.041017e-002
6331, -1.057675e-001, 8.672899e-002, 3.041017e-002
6332, -1.055893e-001, 8.574271e-002, 3.041017e-002
6333, -1.054111e-001, 8.475643e-002, 3.041017e-002
6334, -1.052329e-001, 8.377014e-002, 3.041017e-002
6335, -1.050548e-001, 8.278386e-002, 3.041017e-002
6336, -1.048766e-001, 8.179757e-002, 3.041017e-002
6337, -1.046984e-001, 8.081129e-002, 3.041017e-002
6338, -1.045203e-001, 7.982501e-002, 3.041017e-002
6339, -1.043421e-001, 7.883872e-002, 3.041017e-002
6340, -1.041639e-001, 7.785244e-002, 3.041017e-002
6341, -1.039857e-001, 7.686615e-002, 3.041017e-002
6342, -1.038076e-001, 7.587987e-002, 3.041017e-002
6343, -1.036294e-001, 7.489359e-002, 3.041017e-002
6344, -1.034512e-001, 7.390730e-002, 3.041017e-002
6345, -1.032730e-001, 7.292102e-002, 3.041017e-002
6346, -1.030949e-001, 7.193473e-002, 3.041017e-002
6347, -1.029167e-001, 7.094845e-002, 3.041017e-002
6348, -1.027385e-001, 6.996216e-002, 3.041017e-002
6349, -1.025604e-001, 6.897588e-002, 3.041017e-002
6350, -1.023822e-001, 6.798960e-002, 3.041017e-002
6351, -1.022040e-001, 6.700331e-002, 3.041017e-002
6352, -1.020258e-001, 6.601703e-002, 3.041017e-002
6353, -1.018477e-001, 6.503074e-002, 3.041017e-002
6354, -1.016695e-001, 6.404446e-002, 3.041017e-002
6355, -1.014913e-001, 6.305818e-002, 3.041017e-002
6356, -1.013131e-001, 6.207189e-002, 3.041017e-002
6357, -1.011350e-001, 6.108561e-002, 3.041017e-002
6358, -1.009568e-001, 6.009932e-002, 3.041017e-002
6359, -1.007786e-001, 5.911304e-002, 3.041017e-002
6360, -1.006005e-001, 5.812675e-002, 3.041017e-002
6361, -1.004223e-001, 5.714047e-002, 3.041017e-002
6362, -1.002441e-001, 5.615419e-002, 3.041017e-002
6363, -1.000659e-001, 5.516790e-002, 3.041017e-002
6364, -9.988776e-002, 5.418162e-002, 3.041017e-002
6365, -9.970959e-002, 5.319533e-002, 3.041017e-002
6366, -9.953142e-002, 5.220905e-002, 3.041017e-002
6367, -9.935325e-002, 5.122277e-002, 3.041017e-002
6368, -9.917507e-002, 5.023648e-002, 3.041017e-002
6369, -9.899690e-002, 4.925020e-002, 3.041017e-002
6370, -9.881873e-002, 4.826391e-002, 3.041017e-002
6371, -9.864056e-002, 4.727763e-002, 3.041017e-002
6372, -9.846238e-002, 4.629134e-002, 3.041017e-002
6373, -9.828421e-002, 4.530506e-002, 3.041017e-002
6374, -9.810604e-002, 4.431878e-002, 3.041017e-002
6375, -9.792787e-002, 4.333249e-002, 3.041017e-002
6376, -9.774969e-002, 4.234621e-002, 3.041017e-002
6377, -9.757152e-002, 4.135992e-002, 3.041017e-002
6378, -9.739335e-002, 4.037364e-002, 3.041017e-002
6379, -9.721518e-002, 3.938736e-002, 3.041017e-002
6380, -9.703700e-002, 3.840107e-002, 3.041017e-002
6381, -9.685883e-002, 3.741479e-002, 3.041017e-002
6382, -9.668066e-002, 3.642850e-002, 3.041017e-002
6383, -9.650249e-002, 3.544222e-002, 3.041017e-002
6384, -9.632431e-002, 3.445593e-002, 3.041017e-002
6385, -9.614614e-002, 3.346965e-002, 3.041017e-002
6386, -9.596797e-002, 3.248337e-002, 3.041017e-002
6387, -9.578979e-002, 3.149708e-002, 3.041017e-002
6388, -9.561162e-002, 3.051080e-002, 3.041017e-002
6389, -9.543345e-002, 2.952451e-002, 3.041017e-002
6390, -9.525528e-002, 2.853823e-002, 3.041017e-002
6391, -9.507710e-002, 2.755195e-002, 3.041017e-002
6392, -9.489893e-002, 2.656566e-002, 3.041017e-002
6393, -9.472076e-002, 2.557938e-002, 3.041017e-002
6394, -9.454259e-002, 2.459309e-002, 3.041017e-002
6395, -9.436441e-002, 2.360681e-002, 3.041017e-002
6396, -9.418624e-002, 2.262053e-002, 3.041017e-002
6397, -9.400807e-002, 2.163424e-002, 3.041017e-002
6398, -9.382990e-002, 2.064796e-002, 3.041017e-002
6399, -9.365172e-002, 1.966167e-002, 3.041017e-002
6400, -9.347352e-002, 1.867531e-002, 3.041021e-002
6401, -9.329524e-002, 1.768874e-002, 3.041035e-002
6402, -9.311682e-002, 1.670190e-002, 3.041067e-002
6403, -9.293826e-002, 1.571482e-002, 3.041120e-002
6404, -9.275961e-002, 1.472765e-002, 3.041192e-002
6405, -9.258093e-002, 1.374060e-002, 3.041275e-002
6406, -1.088875e-001, 1.676500e-001, 2.945654e-002
6407, -1.087300e-001, 1.676783e-001, 2.848230e-002
6408, -1.087319e-001, 1.676781e-001, 2.749508e-002
6409, -1.088931e-001, 1.676492e-001, 2.652126e-002
6410, -1.092096e-001, 1.675925e-001, 2.558690e-002
6411, -1.096733e-001, 1.675093e-001, 2.471720e-002
6412, -1.102719e-001, 1.674016e-001, 2.393601e-002
6413, -1.109892e-001, 1.672719e-001, 2.326507e-002
6414, -1.118054e-001, 1.671239e-001, 2.272313e-002
6415, -1.126983e-001, 1.669621e-001, 2.232509e-002
6416, -1.136436e-001, 1.667910e-001, 2.208183e-002
6417, -1.146154e-001, 1.666153e-001, 2.200000e-002
6418, -1.155872e-001, 1.664398e-001, 2.208184e-002
6419, -1.165326e-001, 1.662694e-001, 2.232510e-002
6420, -1.174257e-001, 1.661085e-001, 2.272317e-002
6421, -1.182422e-001, 1.659615e-001, 2.326517e-002
6422, -1.189597e-001, 1.658322e-001, 2.393632e-002
6423, -1.195586e-001, 1.657236e-001, 2.471832e-002
6424, -1.200226e-001, 1.656392e-001, 2.558984e-002
6425, -1.203392e-001, 1.655816e-001, 2.652710e-002
6426, -1.204996e-001, 1.655520e-001, 2.750454e-002
6427, -1.204995e-001, 1.655513e-001, 2.849548e-002
6428, -1.203388e-001, 1.655794e-001, 2.947292e-002
6429, -1.078088e-001, 1.617271e-001, 2.942170e-002
6430, -1.079880e-001, 1.627133e-001, 2.942572e-002
6431, -8.144415e-002, 1.575120e-002, 2.944534e-002
6432, -8.355276e-002, 1.536153e-002, 2.326029e-002
6433, -8.283458e-002, 1.549134e-002, 2.393033e-002
6434, -1.076303e-001, 1.607409e-001, 2.942023e-002
6435, -1.065610e-001, 1.548232e-001, 2.941911e-002
6436, -1.067392e-001, 1.558095e-001, 2.941911e-002
6437, -1.062047e-001, 1.528506e-001, 2.941911e-002
6438, -1.063828e-001, 1.538369e-001, 2.941911e-002
6439, -8.718090e-002, 1.470607e-002, 2.200001e-002
6440, -8.620896e-002, 1.488165e-002, 2.208054e-002
6441, -1.069173e-001, 1.567958e-001, 2.941911e-002
6442, -1.070955e-001, 1.577821e-001, 2.941912e-002
6443, -1.074520e-001, 1.597546e-001, 2.941962e-002
6444, -1.058483e-001, 1.508781e-001, 2.941911e-002
6445, -1.060265e-001, 1.518644e-001, 2.941911e-002
6446, -1.056701e-001, 1.498918e-001, 2.941911e-002
6447, -1.054920e-001, 1.489055e-001, 2.941911e-002
6448, -1.053138e-001, 1.479192e-001, 2.941911e-002
6449, -1.051356e-001, 1.469329e-001, 2.941911e-002
6450, -1.049574e-001, 1.459466e-001, 2.941911e-002
6451, -1.047793e-001, 1.449604e-001, 2.941911e-002
6452, -1.046011e-001, 1.439741e-001, 2.941911e-002
6453, -1.044229e-001, 1.429878e-001, 2.941911e-002
6454, -1.042448e-001, 1.420015e-001, 2.941911e-002
6455, -1.040666e-001, 1.410152e-001, 2.941911e-002
6456, -1.038884e-001, 1.400289e-001, 2.941911e-002
6457, -1.037102e-001, 1.390427e-001, 2.941911e-002
6458, -1.035321e-001, 1.380564e-001, 2.941911e-002
6459, -1.033539e-001, 1.370701e-001, 2.941911e-002
6460, -1.031757e-001, 1.360838e-001, 2.941911e-002
6461, -1.029975e-001, 1.350975e-001, 2.941911e-002
6462, -1.028194e-001, 1.341112e-001, 2.941911e-002
6463, -1.026412e-001, 1.331250e-001, 2.941911e-002
6464, -1.024630e-001, 1.321387e-001, 2.941911e-002
6465, -1.022849e-001, 1.311524e-001, 2.941911e-002
6466, -1.021067e-001, 1.301661e-001, 2.941911e-002
6467, -1.019285e-001, 1.291798e-001, 2.941911e-002
6468, -1.017503e-001, 1.281935e-001, 2.941911e-002
6469, -1.015722e-001, 1.272072e-001, 2.941911e-002
6470, -1.013940e-001, 1.262210e-001, 2.941911e-002
6471, -1.012158e-001, 1.252347e-001, 2.941911e-002
6472, -1.010376e-001, 1.242484e-001, 2.941911e-002
6473, -1.008595e-001, 1.232621e-001, 2.941911e-002
6474, -1.006813e-001, 1.222758e-001, 2.941911e-002
6475, -1.005031e-001, 1.212895e-001, 2.941911e-002
6476, -1.003250e-001, 1.203033e-001, 2.941911e-002
6477, -1.001468e-001, 1.193170e-001, 2.941911e-002
6478, -9.996861e-002, 1.183307e-001, 2.941911e-002
6479, -9.979044e-002, 1.173444e-001, 2.941911e-002
6480, -9.961227e-002, 1.163581e-001, 2.941911e-002
6481, -9.943410e-002, 1.153718e-001, 2.941911e-002
6482, -9.925592e-002, 1.143856e-001, 2.941911e-002
6483, -9.907775e-002, 1.133993e-001, 2.941911e-002
6484, -9.889958e-002, 1.124130e-001, 2.941911e-002
6485, -9.872141e-002, 1.114267e-001, 2.941911e-002
6486, -9.854323e-002, 1.104404e-001, 2.941911e-002
6487, -9.836506e-002, 1.094541e-001, 2.941911e-002
6488, -9.818689e-002, 1.084678e-001, 2.941911e-002
6489, -9.800872e-002, 1.074816e-001, 2.941911e-002
6490, -9.783054e-002, 1.064953e-001, 2.941911e-002
6491, -9.765237e-002, 1.055090e-001, 2.941911e-002
6492, -9.747420e-002, 1.045227e-001, 2.941911e-002
6493, -9.729602e-002, 1.035364e-001, 2.941911e-002
6494, -9.711785e-002, 1.025501e-001, 2.941911e-002
6495, -9.693968e-002, 1.015639e-001, 2.941911e-002
6496, -9.676151e-002, 1.005776e-001, 2.941911e-002
6497, -9.658333e-002, 9.959129e-002, 2.941911e-002
6498, -9.640516e-002, 9.860501e-002, 2.941911e-002
6499, -9.622699e-002, 9.761872e-002, 2.941911e-002
6500, -9.604882e-002, 9.663244e-002, 2.941911e-002
6501, -9.587064e-002, 9.564616e-002, 2.941911e-002
6502, -9.569247e-002, 9.465987e-002, 2.941911e-002
6503, -9.551430e-002, 9.367359e-002, 2.941911e-002
6504, -9.533613e-002, 9.268730e-002, 2.941911e-002
6505, -9.515795e-002, 9.170102e-002, 2.941911e-002
6506, -9.497978e-002, 9.071473e-002, 2.941911e-002
6507, -9.480161e-002, 8.972845e-002, 2.941911e-002
6508, -9.462344e-002, 8.874217e-002, 2.941911e-002
6509, -9.444526e-002, 8.775588e-002, 2.941911e-002
6510, -9.426709e-002, 8.676960e-002, 2.941911e-002
6511, -9.408892e-002, 8.578331e-002, 2.941911e-002
6512, -9.391075e-002, 8.479703e-002, 2.941911e-002
6513, -9.373257e-002, 8.381075e-002, 2.941911e-002
6514, -9.355440e-002, 8.282446e-002, 2.941911e-002
6515, -9.337623e-002, 8.183818e-002, 2.941911e-002
6516, -9.319806e-002, 8.085189e-002, 2.941911e-002
6517, -9.301988e-002, 7.986561e-002, 2.941911e-002
6518, -9.284171e-002, 7.887932e-002, 2.941911e-002
6519, -9.266354e-002, 7.789304e-002, 2.941911e-002
6520, -9.248537e-002, 7.690676e-002, 2.941911e-002
6521, -9.230719e-002, 7.592047e-002, 2.941911e-002
6522, -9.212902e-002, 7.493419e-002, 2.941911e-002
6523, -9.195085e-002, 7.394790e-002, 2.941911e-002
6524, -9.177268e-002, 7.296162e-002, 2.941911e-002
6525, -9.159450e-002, 7.197534e-002, 2.941911e-002
6526, -9.141633e-002, 7.098905e-002, 2.941911e-002
6527, -9.123816e-002, 7.000277e-002, 2.941911e-002
6528, -9.105998e-002, 6.901648e-002, 2.941911e-002
6529, -9.088181e-002, 6.803020e-002, 2.941911e-002
6530, -9.070364e-002, 6.704391e-002, 2.941911e-002
6531, -9.052547e-002, 6.605763e-002, 2.941911e-002
6532, -9.034729e-002, 6.507135e-002, 2.941911e-002
6533, -9.016912e-002, 6.408506e-002, 2.941911e-002
6534, -8.999095e-002, 6.309878e-002, 2.941911e-002
6535, -8.981278e-002, 6.211249e-002, 2.941911e-002
6536, -8.963460e-002, 6.112621e-002, 2.941911e-002
6537, -8.945643e-002, 6.013993e-002, 2.941911e-002
6538, -8.927826e-002, 5.915364e-002, 2.941911e-002
6539, -8.910009e-002, 5.816736e-002, 2.941911e-002
6540, -8.892191e-002, 5.718107e-002, 2.941911e-002
6541, -8.874374e-002, 5.619479e-002, 2.941911e-002
6542, -8.856557e-002, 5.520851e-002, 2.941911e-002
6543, -8.838740e-002, 5.422222e-002, 2.941911e-002
6544, -8.820922e-002, 5.323594e-002, 2.941911e-002
6545, -8.803105e-002, 5.224965e-002, 2.941911e-002
6546, -8.785288e-002, 5.126337e-002, 2.941911e-002
6547, -8.767471e-002, 5.027708e-002, 2.941911e-002
6548, -8.749653e-002, 4.929080e-002, 2.941911e-002
6549, -8.731836e-002, 4.830452e-002, 2.941911e-002
6550, -8.714019e-002, 4.731823e-002, 2.941911e-002
6551, -8.696202e-002, 4.633195e-002, 2.941911e-002
6552, -8.678384e-002, 4.534566e-002, 2.941911e-002
6553, -8.660567e-002, 4.435938e-002, 2.941911e-002
6554, -8.642750e-002, 4.337310e-002, 2.941911e-002
6555, -8.624933e-002, 4.238681e-002, 2.941911e-002
6556, -8.607115e-002, 4.140053e-002, 2.941911e-002
6557, -8.589298e-002, 4.041424e-002, 2.941911e-002
6558, -8.571481e-002, 3.942796e-002, 2.941911e-002
6559, -8.553664e-002, 3.844167e-002, 2.941911e-002
6560, -8.535846e-002, 3.745539e-002, 2.941911e-002
6561, -8.518029e-002, 3.646911e-002, 2.941911e-002
6562, -8.500212e-002, 3.548282e-002, 2.941911e-002
6563, -8.482395e-002, 3.449654e-002, 2.941911e-002
6564, -8.464577e-002, 3.351025e-002, 2.941911e-002
6565, -8.446760e-002, 3.252397e-002, 2.941911e-002
6566, -8.428943e-002, 3.153769e-002, 2.941911e-002
6567, -8.411125e-002, 3.055140e-002, 2.941911e-002
6568, -8.393308e-002, 2.956512e-002, 2.941911e-002
6569, -8.375491e-002, 2.857883e-002, 2.941911e-002
6570, -8.357674e-002, 2.759255e-002, 2.941911e-002
6571, -8.339856e-002, 2.660626e-002, 2.941911e-002
6572, -8.322039e-002, 2.561998e-002, 2.941911e-002
6573, -8.304222e-002, 2.463370e-002, 2.941911e-002
6574, -8.286405e-002, 2.364741e-002, 2.941911e-002
6575, -8.268587e-002, 2.266113e-002, 2.941911e-002
6576, -8.250775e-002, 2.167476e-002, 2.941937e-002
6577, -8.232980e-002, 2.068813e-002, 2.942052e-002
6578, -8.215217e-002, 1.970108e-002, 2.942325e-002
6579, -8.197490e-002, 1.871363e-002, 2.942776e-002
6580, -8.179792e-002, 1.772599e-002, 2.943351e-002
6581, -8.162105e-002, 1.673847e-002, 2.943959e-002
6582, -8.223528e-002, 1.560000e-002, 2.471052e-002
6583, -8.177133e-002, 1.568493e-002, 2.557828e-002
6584, -8.815263e-002, 1.453052e-002, 2.208313e-002
6585, -8.526334e-002, 1.505248e-002, 2.232254e-002
6586, -8.436981e-002, 1.521391e-002, 2.271940e-002
6587, -1.085271e-001, 1.656739e-001, 2.944284e-002
6588, -1.087074e-001, 1.666618e-001, 2.945011e-002
6589, -8.145417e-002, 1.574391e-002, 2.651042e-002
6590, -8.129162e-002, 1.577516e-002, 2.748283e-002
6591, -8.128812e-002, 1.577772e-002, 2.846993e-002
6592, -8.909765e-002, 1.435981e-002, 2.232766e-002
6593, -8.999019e-002, 1.419859e-002, 2.272691e-002
6594, -1.083472e-001, 1.646865e-001, 2.943656e-002
6595, -9.080588e-002, 1.405125e-002, 2.327001e-002
6596, -9.152246e-002, 1.392187e-002, 2.394211e-002
6597, -9.212040e-002, 1.381414e-002, 2.472482e-002
6598, -9.258344e-002, 1.373141e-002, 2.559660e-002
6599, -9.289905e-002, 1.367594e-002, 2.653361e-002
6600, -9.305873e-002, 1.364897e-002, 2.751036e-002
6601, -9.305819e-002, 1.365096e-002, 2.850036e-002
6602, -9.289746e-002, 1.368180e-002, 2.947666e-002
6603, -1.081676e-001, 1.636998e-001, 2.943132e-002
6604, -1.072737e-001, 1.587683e-001, 2.941931e-002
6605, -1.201603e-001, 1.645916e-001, 2.947292e-002
6606, -1.199819e-001, 1.636040e-001, 2.947292e-002
6607, -1.198036e-001, 1.626168e-001, 2.947291e-002
6608, -1.196253e-001, 1.616300e-001, 2.947291e-002
6609, -1.194471e-001, 1.606434e-001, 2.947291e-002
6610, -1.192689e-001, 1.596569e-001, 2.947291e-002
6611, -1.190907e-001, 1.586706e-001, 2.947291e-002
6612, -1.189125e-001, 1.576843e-001, 2.947291e-002
6613, -1.187343e-001, 1.566980e-001, 2.947291e-002
6614, -1.185562e-001, 1.557117e-001, 2.947291e-002
6615, -1.183780e-001, 1.547254e-001, 2.947291e-002
6616, -1.181998e-001, 1.537391e-001, 2.947291e-002
6617, -1.180217e-001, 1.527528e-001, 2.947291e-002
6618, -1.178435e-001, 1.517665e-001, 2.947291e-002
6619, -1.176653e-001, 1.507803e-001, 2.947291e-002
6620, -1.174871e-001, 1.497940e-001, 2.947291e-002
6621, -1.173090e-001, 1.488077e-001, 2.947291e-002
6622, -1.171308e-001, 1.478214e-001, 2.947291e-002
6623, -1.169526e-001, 1.468351e-001, 2.947291e-002
6624, -1.167744e-001, 1.458488e-001, 2.947291e-002
6625, -1.165963e-001, 1.448626e-001, 2.947291e-002
6626, -1.164181e-001, 1.438763e-001, 2.947291e-002
6627, -1.162399e-001, 1.428900e-001, 2.947291e-002
6628, -1.160618e-001, 1.419037e-001, 2.947291e-002
6629, -1.158836e-001, 1.409174e-001, 2.947291e-002
6630, -1.157054e-001, 1.399311e-001, 2.947291e-002
6631, -1.155272e-001, 1.389449e-001, 2.947291e-002
6632, -1.153491e-001, 1.379586e-001, 2.947291e-002
6633, -1.151709e-001, 1.369723e-001, 2.947291e-002
6634, -1.149927e-001, 1.359860e-001, 2.947291e-002
6635, -1.148146e-001, 1.349997e-001, 2.947291e-002
6636, -1.146364e-001, 1.340134e-001, 2.947291e-002
6637, -1.144582e-001, 1.330271e-001, 2.947291e-002
6638, -1.142800e-001, 1.320409e-001, 2.947291e-002
6639, -1.141019e-001, 1.310546e-001, 2.947291e-002
6640, -1.139237e-001, 1.300683e-001, 2.947291e-002
6641, -1.137455e-001, 1.290820e-001, 2.947291e-002
6642, -1.135673e-001, 1.280957e-001, 2.947291e-002
6643, -1.133892e-001, 1.271094e-001, 2.947291e-002
6644, -1.132110e-001, 1.261232e-001, 2.947291e-002
6645, -1.130328e-001, 1.251369e-001, 2.947291e-002
6646, -1.128547e-001, 1.241506e-001, 2.947291e-002
6647, -1.126765e-001, 1.231643e-001, 2.947291e-002
6648, -1.124983e-001, 1.221780e-001, 2.947291e-002
6649, -1.123201e-001, 1.211917e-001, 2.947291e-002
6650, -1.121420e-001, 1.202055e-001, 2.947291e-002
6651, -1.119638e-001, 1.192192e-001, 2.947291e-002
6652, -1.117856e-001, 1.182329e-001, 2.947291e-002
6653, -1.116074e-001, 1.172466e-001, 2.947291e-002
6654, -1.114293e-001, 1.162603e-001, 2.947291e-002
6655, -1.112511e-001, 1.152740e-001, 2.947291e-002
6656, -1.110729e-001, 1.142878e-001, 2.947291e-002
6657, -1.108948e-001, 1.133015e-001, 2.947291e-002
6658, -1.107166e-001, 1.123152e-001, 2.947291e-002
6659, -1.105384e-001, 1.113289e-001, 2.947291e-002
6660, -1.103602e-001, 1.103426e-001, 2.947291e-002
6661, -1.101821e-001, 1.093563e-001, 2.947291e-002
6662, -1.100039e-001, 1.083700e-001, 2.947291e-002
6663, -1.098257e-001, 1.073838e-001, 2.947291e-002
6664, -1.096475e-001, 1.063975e-001, 2.947291e-002
6665, -1.094694e-001, 1.054112e-001, 2.947291e-002
6666, -1.092912e-001, 1.044249e-001, 2.947291e-002
6667, -1.091130e-001, 1.034386e-001, 2.947291e-002
6668, -1.089349e-001, 1.024523e-001, 2.947291e-002
6669, -1.087567e-001, 1.014661e-001, 2.947291e-002
6670, -1.085785e-001, 1.004798e-001, 2.947291e-002
6671, -1.084003e-001, 9.949349e-002, 2.947291e-002
6672, -1.082222e-001, 9.850720e-002, 2.947291e-002
6673, -1.080440e-001, 9.752092e-002, 2.947291e-002
6674, -1.078658e-001, 9.653464e-002, 2.947291e-002
6675, -1.076876e-001, 9.554835e-002, 2.947291e-002
6676, -1.075095e-001, 9.456207e-002, 2.947291e-002
6677, -1.073313e-001, 9.357578e-002, 2.947291e-002
6678, -1.071531e-001, 9.258950e-002, 2.947291e-002
6679, -1.069750e-001, 9.160322e-002, 2.947291e-002
6680, -1.067968e-001, 9.061693e-002, 2.947291e-002
6681, -1.066186e-001, 8.963065e-002, 2.947291e-002
6682, -1.064404e-001, 8.864436e-002, 2.947291e-002
6683, -1.062623e-001, 8.765808e-002, 2.947291e-002
6684, -1.060841e-001, 8.667179e-002, 2.947291e-002
6685, -1.059059e-001, 8.568551e-002, 2.947291e-002
6686, -1.057278e-001, 8.469923e-002, 2.947291e-002
6687, -1.055496e-001, 8.371294e-002, 2.947291e-002
6688, -1.053714e-001, 8.272666e-002, 2.947291e-002
6689, -1.051932e-001, 8.174037e-002, 2.947291e-002
6690, -1.050151e-001, 8.075409e-002, 2.947291e-002
6691, -1.048369e-001, 7.976781e-002, 2.947291e-002
6692, -1.046587e-001, 7.878152e-002, 2.947291e-002
6693, -1.044805e-001, 7.779524e-002, 2.947291e-002
6694, -1.043024e-001, 7.680895e-002, 2.947291e-002
6695, -1.041242e-001, 7.582267e-002, 2.947291e-002
6696, -1.039460e-001, 7.483638e-002, 2.947291e-002
6697, -1.037679e-001, 7.385010e-002, 2.947291e-002
6698, -1.035897e-001, 7.286382e-002, 2.947291e-002
6699, -1.034115e-001, 7.187753e-002, 2.947291e-002
6700, -1.032333e-001, 7.089125e-002, 2.947291e-002
6701, -1.030552e-001, 6.990496e-002, 2.947291e-002
6702, -1.028770e-001, 6.891868e-002, 2.947291e-002
6703, -1.026988e-001, 6.793240e-002, 2.947291e-002
6704, -1.025206e-001, 6.694611e-002, 2.947291e-002
6705, -1.023425e-001, 6.595983e-002, 2.947291e-002
6706, -1.021643e-001, 6.497354e-002, 2.947291e-002
6707, -1.019861e-001, 6.398726e-002, 2.947291e-002
6708, -1.018080e-001, 6.300097e-002, 2.947291e-002
6709, -1.016298e-001, 6.201469e-002, 2.947291e-002
6710, -1.014516e-001, 6.102841e-002, 2.947291e-002
6711, -1.012734e-001, 6.004212e-002, 2.947291e-002
6712, -1.010953e-001, 5.905584e-002, 2.947291e-002
6713, -1.009171e-001, 5.806955e-002, 2.947291e-002
6714, -1.007389e-001, 5.708327e-002, 2.947291e-002
6715, -1.005607e-001, 5.609699e-002, 2.947291e-002
6716, -1.003826e-001, 5.511070e-002, 2.947291e-002
6717, -1.002044e-001, 5.412442e-002, 2.947291e-002
6718, -1.000262e-001, 5.313813e-002, 2.947291e-002
6719, -9.984806e-002, 5.215185e-002, 2.947291e-002
6720, -9.966988e-002, 5.116556e-002, 2.947291e-002
6721, -9.949171e-002, 5.017928e-002, 2.947291e-002
6722, -9.931354e-002, 4.919300e-002, 2.947291e-002
6723, -9.913537e-002, 4.820671e-002, 2.947291e-002
6724, -9.895719e-002, 4.722043e-002, 2.947291e-002
6725, -9.877902e-002, 4.623414e-002, 2.947291e-002
6726, -9.860085e-002, 4.524786e-002, 2.947291e-002
6727, -9.842267e-002, 4.426158e-002, 2.947291e-002
6728, -9.824450e-002, 4.327529e-002, 2.947291e-002
6729, -9.806633e-002, 4.228901e-002, 2.947291e-002
6730, -9.788816e-002, 4.130272e-002, 2.947291e-002
6731, -9.770998e-002, 4.031644e-002, 2.947291e-002
6732, -9.753181e-002, 3.933016e-002, 2.947291e-002
6733, -9.735364e-002, 3.834387e-002, 2.947291e-002
6734, -9.717547e-002, 3.735759e-002, 2.947291e-002
6735, -9.699729e-002, 3.637130e-002, 2.947291e-002
6736, -9.681912e-002, 3.538502e-002, 2.947291e-002
6737, -9.664095e-002, 3.439873e-002, 2.947291e-002
6738, -9.646278e-002, 3.341245e-002, 2.947291e-002
6739, -9.628460e-002, 3.242617e-002, 2.947291e-002
6740, -9.610643e-002, 3.143988e-002, 2.947291e-002
6741, -9.592826e-002, 3.045360e-002, 2.947291e-002
6742, -9.575009e-002, 2.946731e-002, 2.947291e-002
6743, -9.557191e-002, 2.848103e-002, 2.947291e-002
6744, -9.539374e-002, 2.749475e-002, 2.947291e-002
6745, -9.521557e-002, 2.650846e-002, 2.947291e-002
6746, -9.503740e-002, 2.552218e-002, 2.947291e-002
6747, -9.485922e-002, 2.453589e-002, 2.947291e-002
6748, -9.468105e-002, 2.354961e-002, 2.947291e-002
6749, -9.450288e-002, 2.256332e-002, 2.947291e-002
6750, -9.432471e-002, 2.157704e-002, 2.947291e-002
6751, -9.414653e-002, 2.059076e-002, 2.947291e-002
6752, -9.396833e-002, 1.960437e-002, 2.947295e-002
6753, -9.379005e-002, 1.861770e-002, 2.947311e-002
6754, -9.361165e-002, 1.763068e-002, 2.947349e-002
6755, -9.343313e-002, 1.664338e-002, 2.947410e-002
6756, -9.325456e-002, 1.565599e-002, 2.947490e-002
6757, -9.307598e-002, 1.466876e-002, 2.947578e-002
6758, -1.085510e-001, 1.666901e-001, 2.847618e-002
6759, -1.085537e-001, 1.666896e-001, 2.748993e-002
6760, -1.087155e-001, 1.666604e-001, 2.651750e-002
6761, -1.090319e-001, 1.666033e-001, 2.558462e-002
6762, -1.094952e-001, 1.665195e-001, 2.471615e-002
6763, -1.100933e-001, 1.664113e-001, 2.393569e-002
6764, -1.108105e-001, 1.662819e-001, 2.326498e-002
6765, -1.116267e-001, 1.661346e-001, 2.272310e-002
6766, -1.125197e-001, 1.659733e-001, 2.232508e-002
6767, -1.134650e-001, 1.658026e-001, 2.208183e-002
6768, -1.144368e-001, 1.656270e-001, 2.200000e-002
6769, -1.154087e-001, 1.654514e-001, 2.208184e-002
6770, -1.163540e-001, 1.652806e-001, 2.232510e-002
6771, -1.172470e-001, 1.651192e-001, 2.272316e-002
6772, -1.180634e-001, 1.649716e-001, 2.326516e-002
6773, -1.187808e-001, 1.648419e-001, 2.393632e-002
6774, -1.193798e-001, 1.647340e-001, 2.471832e-002
6775, -1.198440e-001, 1.646503e-001, 2.558983e-002
6776, -1.201606e-001, 1.645930e-001, 2.652710e-002
6777, -1.203211e-001, 1.645638e-001, 2.750453e-002
6778, -1.203210e-001, 1.645633e-001, 2.849548e-002
6779, -8.927546e-002, 1.534391e-002, 2.232766e-002
6780, -8.833044e-002, 1.551462e-002, 2.208314e-002
6781, -8.241461e-002, 1.658469e-002, 2.470836e-002
6782, -8.195143e-002, 1.667038e-002, 2.557364e-002
6783, -1.053398e-001, 1.489330e-001, 2.843232e-002
6784, -1.055180e-001, 1.499193e-001, 2.843232e-002
6785, -8.373071e-002, 1.634566e-002, 2.326016e-002
6786, -8.301311e-002, 1.647566e-002, 2.392957e-002
6787, -8.147045e-002, 1.676179e-002, 2.747607e-002
6788, -8.146591e-002, 1.676474e-002, 2.846340e-002
6789, -9.323655e-002, 1.463784e-002, 2.849942e-002
6790, -1.074781e-001, 1.607684e-001, 2.843575e-002
6791, -1.076566e-001, 1.617546e-001, 2.843988e-002
6792, -1.064088e-001, 1.548507e-001, 2.843232e-002
6793, -1.065870e-001, 1.558370e-001, 2.843232e-002
6794, -1.062306e-001, 1.538644e-001, 2.843232e-002
6795, -1.078353e-001, 1.627410e-001, 2.844666e-002
6796, -1.080141e-001, 1.637276e-001, 2.845452e-002
6797, -1.081930e-001, 1.647146e-001, 2.846212e-002
6798, -1.072998e-001, 1.597821e-001, 2.843428e-002
6799, -1.051616e-001, 1.479467e-001, 2.843232e-002
6800, -1.056961e-001, 1.509056e-001, 2.843232e-002
6801, -1.049834e-001, 1.469604e-001, 2.843232e-002
6802, -1.048053e-001, 1.459741e-001, 2.843232e-002
6803, -1.046271e-001, 1.449879e-001, 2.843232e-002
6804, -1.044489e-001, 1.440016e-001, 2.843232e-002
6805, -1.042707e-001, 1.430153e-001, 2.843232e-002
6806, -1.040926e-001, 1.420290e-001, 2.843232e-002
6807, -1.039144e-001, 1.410427e-001, 2.843232e-002
6808, -1.037362e-001, 1.400564e-001, 2.843232e-002
6809, -1.035581e-001, 1.390701e-001, 2.843232e-002
6810, -1.033799e-001, 1.380839e-001, 2.843232e-002
6811, -1.032017e-001, 1.370976e-001, 2.843232e-002
6812, -1.030235e-001, 1.361113e-001, 2.843232e-002
6813, -1.028454e-001, 1.351250e-001, 2.843232e-002
6814, -1.026672e-001, 1.341387e-001, 2.843232e-002
6815, -1.024890e-001, 1.331524e-001, 2.843232e-002
6816, -1.023109e-001, 1.321662e-001, 2.843232e-002
6817, -1.021327e-001, 1.311799e-001, 2.843232e-002
6818, -1.019545e-001, 1.301936e-001, 2.843232e-002
6819, -1.017763e-001, 1.292073e-001, 2.843232e-002
6820, -1.015982e-001, 1.282210e-001, 2.843232e-002
6821, -1.014200e-001, 1.272347e-001, 2.843232e-002
6822, -1.012418e-001, 1.262485e-001, 2.843232e-002
6823, -1.010636e-001, 1.252622e-001, 2.843232e-002
6824, -1.008855e-001, 1.242759e-001, 2.843232e-002
6825, -1.007073e-001, 1.232896e-001, 2.843232e-002
6826, -1.005291e-001, 1.223033e-001, 2.843232e-002
6827, -1.003510e-001, 1.213170e-001, 2.843232e-002
6828, -1.001728e-001, 1.203308e-001, 2.843232e-002
6829, -9.999461e-002, 1.193445e-001, 2.843232e-002
6830, -9.981643e-002, 1.183582e-001, 2.843232e-002
6831, -9.963826e-002, 1.173719e-001, 2.843232e-002
6832, -9.946009e-002, 1.163856e-001, 2.843232e-002
6833, -9.928192e-002, 1.153993e-001, 2.843232e-002
6834, -9.910374e-002, 1.144130e-001, 2.843232e-002
6835, -9.892557e-002, 1.134268e-001, 2.843232e-002
6836, -9.874740e-002, 1.124405e-001, 2.843232e-002
6837, -9.856923e-002, 1.114542e-001, 2.843232e-002
6838, -9.839105e-002, 1.104679e-001, 2.843232e-002
6839, -9.821288e-002, 1.094816e-001, 2.843232e-002
6840, -9.803471e-002, 1.084953e-001, 2.843232e-002
6841, -9.785654e-002, 1.075091e-001, 2.843232e-002
6842, -9.767836e-002, 1.065228e-001, 2.843232e-002
6843, -9.750019e-002, 1.055365e-001, 2.843232e-002
6844, -9.732202e-002, 1.045502e-001, 2.843232e-002
6845, -9.714385e-002, 1.035639e-001, 2.843232e-002
6846, -9.696567e-002, 1.025776e-001, 2.843232e-002
6847, -9.678750e-002, 1.015914e-001, 2.843232e-002
6848, -9.660933e-002, 1.006051e-001, 2.843232e-002
6849, -9.643116e-002, 9.961878e-002, 2.843232e-002
6850, -9.625298e-002, 9.863250e-002, 2.843232e-002
6851, -9.607481e-002, 9.764621e-002, 2.843232e-002
6852, -9.589664e-002, 9.665993e-002, 2.843232e-002
6853, -9.571847e-002, 9.567365e-002, 2.843232e-002
6854, -9.554029e-002, 9.468736e-002, 2.843232e-002
6855, -9.536212e-002, 9.370108e-002, 2.843232e-002
6856, -9.518395e-002, 9.271479e-002, 2.843232e-002
6857, -9.500577e-002, 9.172851e-002, 2.843232e-002
6858, -9.482760e-002, 9.074223e-002, 2.843232e-002
6859, -9.464943e-002, 8.975594e-002, 2.843232e-002
6860, -9.447126e-002, 8.876966e-002, 2.843232e-002
6861, -9.429308e-002, 8.778337e-002, 2.843232e-002
6862, -9.411491e-002, 8.679709e-002, 2.843232e-002
6863, -9.393674e-002, 8.581081e-002, 2.843232e-002
6864, -9.375857e-002, 8.482452e-002, 2.843232e-002
6865, -9.358039e-002, 8.383824e-002, 2.843232e-002
6866, -9.340222e-002, 8.285195e-002, 2.843232e-002
6867, -9.322405e-002, 8.186567e-002, 2.843232e-002
6868, -9.304588e-002, 8.087938e-002, 2.843232e-002
6869, -9.286770e-002, 7.989310e-002, 2.843232e-002
6870, -9.268953e-002, 7.890682e-002, 2.843232e-002
6871, -9.251136e-002, 7.792053e-002, 2.843232e-002
6872, -9.233319e-002, 7.693425e-002, 2.843232e-002
6873, -9.215501e-002, 7.594796e-002, 2.843232e-002
6874, -9.197684e-002, 7.496168e-002, 2.843232e-002
6875, -9.179867e-002, 7.397540e-002, 2.843232e-002
6876, -9.162050e-002, 7.298911e-002, 2.843232e-002
6877, -9.144232e-002, 7.200283e-002, 2.843232e-002
6878, -9.126415e-002, 7.101654e-002, 2.843232e-002
6879, -9.108598e-002, 7.003026e-002, 2.843232e-002
6880, -9.090781e-002, 6.904397e-002, 2.843232e-002
6881, -9.072963e-002, 6.805769e-002, 2.843232e-002
6882, -9.055146e-002, 6.707141e-002, 2.843232e-002
6883, -9.037329e-002, 6.608512e-002, 2.843232e-002
6884, -9.019512e-002, 6.509884e-002, 2.843232e-002
6885, -9.001694e-002, 6.411255e-002, 2.843232e-002
6886, -8.983877e-002, 6.312627e-002, 2.843232e-002
6887, -8.966060e-002, 6.213999e-002, 2.843232e-002
6888, -8.948243e-002, 6.115370e-002, 2.843232e-002
6889, -8.930425e-002, 6.016742e-002, 2.843232e-002
6890, -8.912608e-002, 5.918113e-002, 2.843232e-002
6891, -8.894791e-002, 5.819485e-002, 2.843232e-002
6892, -8.876974e-002, 5.720856e-002, 2.843232e-002
6893, -8.859156e-002, 5.622228e-002, 2.843232e-002
6894, -8.841339e-002, 5.523600e-002, 2.843232e-002
6895, -8.823522e-002, 5.424971e-002, 2.843232e-002
6896, -8.805704e-002, 5.326343e-002, 2.843232e-002
6897, -8.787887e-002, 5.227714e-002, 2.843232e-002
6898, -8.770070e-002, 5.129086e-002, 2.843232e-002
6899, -8.752253e-002, 5.030458e-002, 2.843232e-002
6900, -8.734435e-002, 4.931829e-002, 2.843232e-002
6901, -8.716618e-002, 4.833201e-002, 2.843232e-002
6902, -8.698801e-002, 4.734572e-002, 2.843232e-002
6903, -8.680984e-002, 4.635944e-002, 2.843232e-002
6904, -8.663166e-002, 4.537315e-002, 2.843232e-002
6905, -8.645349e-002, 4.438687e-002, 2.843232e-002
6906, -8.627532e-002, 4.340059e-002, 2.843232e-002
6907, -8.609715e-002, 4.241430e-002, 2.843232e-002
6908, -8.591897e-002, 4.142802e-002, 2.843232e-002
6909, -8.574080e-002, 4.044173e-002, 2.843232e-002
6910, -8.556263e-002, 3.945545e-002, 2.843232e-002
6911, -8.538446e-002, 3.846917e-002, 2.843232e-002
6912, -8.520628e-002, 3.748288e-002, 2.843232e-002
6913, -8.502811e-002, 3.649660e-002, 2.843232e-002
6914, -8.484994e-002, 3.551031e-002, 2.843232e-002
6915, -8.467177e-002, 3.452403e-002, 2.843232e-002
6916, -8.449359e-002, 3.353775e-002, 2.843232e-002
6917, -8.431542e-002, 3.255146e-002, 2.843232e-002
6918, -8.413725e-002, 3.156518e-002, 2.843232e-002
6919, -8.395908e-002, 3.057889e-002, 2.843232e-002
6920, -8.378090e-002, 2.959261e-002, 2.843232e-002
6921, -8.360273e-002, 2.860632e-002, 2.843232e-002
6922, -8.342456e-002, 2.762004e-002, 2.843232e-002
6923, -8.324639e-002, 2.663376e-002, 2.843232e-002
6924, -8.306821e-002, 2.564747e-002, 2.843232e-002
6925, -8.289004e-002, 2.466119e-002, 2.843232e-002
6926, -8.271187e-002, 2.367490e-002, 2.843232e-002
6927, -8.253370e-002, 2.268852e-002, 2.843266e-002
6928, -8.235557e-002, 2.170186e-002, 2.843409e-002
6929, -8.217749e-002, 2.071479e-002, 2.843731e-002
6930, -8.199949e-002, 1.972731e-002, 2.844253e-002
6931, -8.182158e-002, 1.873962e-002, 2.844929e-002
6932, -8.164374e-002, 1.775202e-002, 2.845670e-002
6933, -9.098366e-002, 1.503545e-002, 2.327000e-002
6934, -9.016798e-002, 1.518272e-002, 2.272692e-002
6935, -8.454768e-002, 1.619801e-002, 2.271936e-002
6936, -1.060525e-001, 1.528781e-001, 2.843232e-002
6937, -8.735871e-002, 1.569015e-002, 2.200001e-002
6938, -8.544117e-002, 1.603657e-002, 2.232253e-002
6939, -1.058743e-001, 1.518918e-001, 2.843231e-002
6940, -1.069433e-001, 1.578095e-001, 2.843244e-002
6941, -1.071216e-001, 1.587958e-001, 2.843315e-002
6942, -1.083720e-001, 1.657021e-001, 2.846940e-002
6943, -8.638678e-002, 1.586573e-002, 2.208054e-002
6944, -9.229818e-002, 1.479913e-002, 2.472457e-002
6945, -9.170023e-002, 1.490636e-002, 2.394202e-002
6946, -9.276127e-002, 1.471715e-002, 2.559605e-002
6947, -9.307702e-002, 1.466231e-002, 2.653280e-002
6948, -9.323691e-002, 1.463575e-002, 2.750941e-002
6949, -1.067652e-001, 1.568233e-001, 2.843235e-002
6950, -1.201425e-001, 1.635755e-001, 2.849548e-002
6951, -1.199641e-001, 1.625881e-001, 2.849548e-002
6952, -1.197859e-001, 1.616011e-001, 2.849548e-002
6953, -1.196076e-001, 1.606145e-001, 2.849548e-002
6954, -1.194294e-001, 1.596280e-001, 2.849548e-002
6955, -1.192512e-001, 1.586416e-001, 2.849548e-002
6956, -1.190730e-001, 1.576553e-001, 2.849548e-002
6957, -1.188949e-001, 1.566690e-001, 2.849548e-002
6958, -1.187167e-001, 1.556827e-001, 2.849548e-002
6959, -1.185385e-001, 1.546964e-001, 2.849548e-002
6960, -1.183603e-001, 1.537101e-001, 2.849548e-002
6961, -1.181822e-001, 1.527238e-001, 2.849548e-002
6962, -1.180040e-001, 1.517376e-001, 2.849548e-002
6963, -1.178258e-001, 1.507513e-001, 2.849548e-002
6964, -1.176476e-001, 1.497650e-001, 2.849548e-002
6965, -1.174695e-001, 1.487787e-001, 2.849548e-002
6966, -1.172913e-001, 1.477924e-001, 2.849548e-002
6967, -1.171131e-001, 1.468061e-001, 2.849548e-002
6968, -1.169350e-001, 1.458198e-001, 2.849548e-002
6969, -1.167568e-001, 1.448336e-001, 2.849548e-002
6970, -1.165786e-001, 1.438473e-001, 2.849548e-002
6971, -1.164004e-001, 1.428610e-001, 2.849548e-002
6972, -1.162223e-001, 1.418747e-001, 2.849548e-002
6973, -1.160441e-001, 1.408884e-001, 2.849548e-002
6974, -1.158659e-001, 1.399021e-001, 2.849548e-002
6975, -1.156877e-001, 1.389159e-001, 2.849548e-002
6976, -1.155096e-001, 1.379296e-001, 2.849548e-002
6977, -1.153314e-001, 1.369433e-001, 2.849548e-002
6978, -1.151532e-001, 1.359570e-001, 2.849548e-002
6979, -1.149751e-001, 1.349707e-001, 2.849548e-002
6980, -1.147969e-001, 1.339844e-001, 2.849548e-002
6981, -1.146187e-001, 1.329982e-001, 2.849548e-002
6982, -1.144405e-001, 1.320119e-001, 2.849548e-002
6983, -1.142624e-001, 1.310256e-001, 2.849548e-002
6984, -1.140842e-001, 1.300393e-001, 2.849548e-002
6985, -1.139060e-001, 1.290530e-001, 2.849548e-002
6986, -1.137279e-001, 1.280667e-001, 2.849548e-002
6987, -1.135497e-001, 1.270804e-001, 2.849548e-002
6988, -1.133715e-001, 1.260942e-001, 2.849548e-002
6989, -1.131933e-001, 1.251079e-001, 2.849548e-002
6990, -1.130152e-001, 1.241216e-001, 2.849548e-002
6991, -1.128370e-001, 1.231353e-001, 2.849548e-002
6992, -1.126588e-001, 1.221490e-001, 2.849548e-002
6993, -1.124806e-001, 1.211627e-001, 2.849548e-002
6994, -1.123025e-001, 1.201765e-001, 2.849548e-002
6995, -1.121243e-001, 1.191902e-001, 2.849548e-002
6996, -1.119461e-001, 1.182039e-001, 2.849548e-002
6997, -1.117680e-001, 1.172176e-001, 2.849548e-002
6998, -1.115898e-001, 1.162313e-001, 2.849548e-002
6999, -1.114116e-001, 1.152450e-001, 2.849548e-002
7000, -1.112334e-001, 1.142588e-001, 2.849548e-002
7001, -1.110553e-001, 1.132725e-001, 2.849548e-002
7002, -1.108771e-001, 1.122862e-001, 2.849548e-002
7003, -1.106989e-001, 1.112999e-001, 2.849548e-002
7004, -1.105207e-001, 1.103136e-001, 2.849548e-002
7005, -1.103426e-001, 1.093273e-001, 2.849548e-002
7006, -1.101644e-001, 1.083410e-001, 2.849548e-002
7007, -1.099862e-001, 1.073548e-001, 2.849548e-002
7008, -1.098081e-001, 1.063685e-001, 2.849548e-002
7009, -1.096299e-001, 1.053822e-001, 2.849548e-002
7010, -1.094517e-001, 1.043959e-001, 2.849548e-002
7011, -1.092735e-001, 1.034096e-001, 2.849548e-002
7012, -1.090954e-001, 1.024233e-001, 2.849548e-002
7013, -1.089172e-001, 1.014371e-001, 2.849548e-002
7014, -1.087390e-001, 1.004508e-001, 2.849548e-002
7015, -1.085608e-001, 9.946449e-002, 2.849548e-002
7016, -1.083827e-001, 9.847821e-002, 2.849548e-002
7017, -1.082045e-001, 9.749192e-002, 2.849548e-002
7018, -1.080263e-001, 9.650564e-002, 2.849548e-002
7019, -1.078482e-001, 9.551936e-002, 2.849548e-002
7020, -1.076700e-001, 9.453307e-002, 2.849548e-002
7021, -1.074918e-001, 9.354679e-002, 2.849548e-002
7022, -1.073136e-001, 9.256050e-002, 2.849548e-002
7023, -1.071355e-001, 9.157422e-002, 2.849548e-002
7024, -1.069573e-001, 9.058794e-002, 2.849548e-002
7025, -1.067791e-001, 8.960165e-002, 2.849548e-002
7026, -1.066009e-001, 8.861537e-002, 2.849548e-002
7027, -1.064228e-001, 8.762908e-002, 2.849548e-002
7028, -1.062446e-001, 8.664280e-002, 2.849548e-002
7029, -1.060664e-001, 8.565651e-002, 2.849548e-002
7030, -1.058883e-001, 8.467023e-002, 2.849548e-002
7031, -1.057101e-001, 8.368395e-002, 2.849548e-002
7032, -1.055319e-001, 8.269766e-002, 2.849548e-002
7033, -1.053537e-001, 8.171138e-002, 2.849548e-002
7034, -1.051756e-001, 8.072509e-002, 2.849548e-002
7035, -1.049974e-001, 7.973881e-002, 2.849548e-002
7036, -1.048192e-001, 7.875253e-002, 2.849548e-002
7037, -1.046410e-001, 7.776624e-002, 2.849548e-002
7038, -1.044629e-001, 7.677996e-002, 2.849548e-002
7039, -1.042847e-001, 7.579367e-002, 2.849548e-002
7040, -1.041065e-001, 7.480739e-002, 2.849548e-002
7041, -1.039284e-001, 7.382110e-002, 2.849548e-002
7042, -1.037502e-001, 7.283482e-002, 2.849548e-002
7043, -1.035720e-001, 7.184854e-002, 2.849548e-002
7044, -1.033938e-001, 7.086225e-002, 2.849548e-002
7045, -1.032157e-001, 6.987597e-002, 2.849548e-002
7046, -1.030375e-001, 6.888968e-002, 2.849548e-002
7047, -1.028593e-001, 6.790340e-002, 2.849548e-002
7048, -1.026812e-001, 6.691712e-002, 2.849548e-002
7049, -1.025030e-001, 6.593083e-002, 2.849548e-002
7050, -1.023248e-001, 6.494455e-002, 2.849548e-002
7051, -1.021466e-001, 6.395826e-002, 2.849548e-002
7052, -1.019685e-001, 6.297198e-002, 2.849548e-002
7053, -1.017903e-001, 6.198569e-002, 2.849548e-002
7054, -1.016121e-001, 6.099941e-002, 2.849548e-002
7055, -1.014339e-001, 6.001313e-002, 2.849548e-002
7056, -1.012558e-001, 5.902684e-002, 2.849548e-002
7057, -1.010776e-001, 5.804056e-002, 2.849548e-002
7058, -1.008994e-001, 5.705427e-002, 2.849548e-002
7059, -1.007213e-001, 5.606799e-002, 2.849548e-002
7060, -1.005431e-001, 5.508171e-002, 2.849548e-002
7061, -1.003649e-001, 5.409542e-002, 2.849548e-002
7062, -1.001867e-001, 5.310914e-002, 2.849548e-002
7063, -1.000086e-001, 5.212285e-002, 2.849548e-002
7064, -9.983039e-002, 5.113657e-002, 2.849548e-002
7065, -9.965222e-002, 5.015029e-002, 2.849548e-002
7066, -9.947404e-002, 4.916400e-002, 2.849548e-002
7067, -9.929587e-002, 4.817772e-002, 2.849548e-002
7068, -9.911770e-002, 4.719143e-002, 2.849548e-002
7069, -9.893953e-002, 4.620515e-002, 2.849548e-002
7070, -9.876135e-002, 4.521886e-002, 2.849548e-002
7071, -9.858318e-002, 4.423258e-002, 2.849548e-002
7072, -9.840501e-002, 4.324630e-002, 2.849548e-002
7073, -9.822684e-002, 4.226001e-002, 2.849548e-002
7074, -9.804866e-002, 4.127373e-002, 2.849548e-002
7075, -9.787049e-002, 4.028744e-002, 2.849548e-002
7076, -9.769232e-002, 3.930116e-002, 2.849548e-002
7077, -9.751415e-002, 3.831488e-002, 2.849548e-002
7078, -9.733597e-002, 3.732859e-002, 2.849548e-002
7079, -9.715780e-002, 3.634231e-002, 2.849548e-002
7080, -9.697963e-002, 3.535602e-002, 2.849548e-002
7081, -9.680146e-002, 3.436974e-002, 2.849548e-002
7082, -9.662328e-002, 3.338345e-002, 2.849548e-002
7083, -9.644511e-002, 3.239717e-002, 2.849548e-002
7084, -9.626694e-002, 3.141089e-002, 2.849548e-002
7085, -9.608877e-002, 3.042460e-002, 2.849548e-002
7086, -9.591059e-002, 2.943832e-002, 2.849548e-002
7087, -9.573242e-002, 2.845203e-002, 2.849548e-002
7088, -9.555425e-002, 2.746575e-002, 2.849548e-002
7089, -9.537608e-002, 2.647947e-002, 2.849548e-002
7090, -9.519790e-002, 2.549318e-002, 2.849548e-002
7091, -9.501973e-002, 2.450690e-002, 2.849548e-002
7092, -9.484156e-002, 2.352061e-002, 2.849548e-002
7093, -9.466339e-002, 2.253433e-002, 2.849548e-002
7094, -9.448521e-002, 2.154804e-002, 2.849548e-002
7095, -9.430702e-002, 2.056167e-002, 2.849552e-002
7096, -9.412876e-002, 1.957498e-002, 2.849569e-002
7097, -9.395040e-002, 1.858782e-002, 2.849607e-002
7098, -9.377194e-002, 1.760027e-002, 2.849670e-002
7099, -9.359345e-002, 1.661260e-002, 2.849752e-002
7100, -9.341498e-002, 1.562508e-002, 2.849845e-002
7101, -8.163397e-002, 1.673011e-002, 2.650413e-002
7102, -1.083758e-001, 1.657014e-001, 2.748366e-002
7103, -1.085382e-001, 1.656720e-001, 2.651237e-002
7104, -1.088549e-001, 1.656146e-001, 2.558107e-002
7105, -1.093178e-001, 1.655307e-001, 2.471425e-002
7106, -1.099153e-001, 1.654225e-001, 2.393500e-002
7107, -1.106321e-001, 1.652932e-001, 2.326475e-002
7108, -1.114483e-001, 1.651461e-001, 2.272302e-002
7109, -1.123413e-001, 1.649851e-001, 2.232505e-002
7110, -1.132866e-001, 1.648145e-001, 2.208182e-002
7111, -1.142584e-001, 1.646390e-001, 2.200000e-002
7112, -1.152302e-001, 1.644634e-001, 2.208184e-002
7113, -1.161755e-001, 1.642924e-001, 2.232510e-002
7114, -1.170685e-001, 1.641308e-001, 2.272316e-002
7115, -1.178848e-001, 1.639830e-001, 2.326516e-002
7116, -1.186022e-001, 1.638532e-001, 2.393631e-002
7117, -1.192012e-001, 1.637453e-001, 2.471831e-002
7118, -1.196654e-001, 1.636618e-001, 2.558983e-002
7119, -1.199821e-001, 1.636049e-001, 2.652709e-002
7120, -1.201426e-001, 1.635758e-001, 2.750453e-002
7121, -8.259520e-002, 1.756996e-002, 2.470445e-002
7122, -8.213240e-002, 1.765644e-002, 2.556734e-002
7123, -1.076657e-001, 1.617530e-001, 2.744836e-002
7124, -1.078430e-001, 1.627396e-001, 2.745808e-002
7125, -1.058853e-001, 1.518899e-001, 2.743354e-002
7126, -1.060635e-001, 1.528761e-001, 2.743354e-002
7127, -8.390908e-002, 1.732992e-002, 2.325973e-002
7128, -8.319249e-002, 1.746029e-002, 2.392796e-002
7129, -8.181412e-002, 1.771674e-002, 2.649682e-002
7130, -9.034576e-002, 1.616696e-002, 2.272691e-002
7131, -8.945324e-002, 1.632809e-002, 2.232766e-002
7132, -1.065980e-001, 1.558350e-001, 2.743356e-002
7133, -1.067762e-001, 1.568213e-001, 2.743367e-002
7134, -1.074881e-001, 1.607666e-001, 2.744250e-002
7135, -8.561902e-002, 1.702066e-002, 2.232250e-002
7136, -8.472572e-002, 1.718216e-002, 2.271922e-002
7137, -1.062417e-001, 1.538624e-001, 2.743354e-002
7138, -1.064198e-001, 1.548487e-001, 2.743354e-002
7139, -1.080204e-001, 1.637265e-001, 2.746775e-002
7140, -8.656461e-002, 1.684982e-002, 2.208053e-002
7141, -9.325509e-002, 1.564928e-002, 2.653188e-002
7142, -9.293919e-002, 1.570378e-002, 2.559535e-002
7143, -1.048163e-001, 1.459721e-001, 2.743354e-002
7144, -1.049945e-001, 1.469584e-001, 2.743354e-002
7145, -1.055290e-001, 1.499173e-001, 2.743354e-002
7146, -1.057072e-001, 1.509036e-001, 2.743354e-002
7147, -1.046381e-001, 1.449859e-001, 2.743354e-002
7148, -1.044599e-001, 1.439996e-001, 2.743354e-002
7149, -1.042818e-001, 1.430133e-001, 2.743354e-002
7150, -1.041036e-001, 1.420270e-001, 2.743354e-002
7151, -1.039254e-001, 1.410407e-001, 2.743354e-002
7152, -1.037473e-001, 1.400544e-001, 2.743354e-002
7153, -1.035691e-001, 1.390682e-001, 2.743354e-002
7154, -1.033909e-001, 1.380819e-001, 2.743354e-002
7155, -1.032127e-001, 1.370956e-001, 2.743354e-002
7156, -1.030346e-001, 1.361093e-001, 2.743354e-002
7157, -1.028564e-001, 1.351230e-001, 2.743354e-002
7158, -1.026782e-001, 1.341367e-001, 2.743354e-002
7159, -1.025000e-001, 1.331505e-001, 2.743354e-002
7160, -1.023219e-001, 1.321642e-001, 2.743354e-002
7161, -1.021437e-001, 1.311779e-001, 2.743354e-002
7162, -1.019655e-001, 1.301916e-001, 2.743354e-002
7163, -1.017874e-001, 1.292053e-001, 2.743354e-002
7164, -1.016092e-001, 1.282190e-001, 2.743354e-002
7165, -1.014310e-001, 1.272327e-001, 2.743354e-002
7166, -1.012528e-001, 1.262465e-001, 2.743354e-002
7167, -1.010747e-001, 1.252602e-001, 2.743354e-002
7168, -1.008965e-001, 1.242739e-001, 2.743354e-002
7169, -1.007183e-001, 1.232876e-001, 2.743354e-002
7170, -1.005402e-001, 1.223013e-001, 2.743354e-002
7171, -1.003620e-001, 1.213150e-001, 2.743354e-002
7172, -1.001838e-001, 1.203288e-001, 2.743354e-002
7173, -1.000056e-001, 1.193425e-001, 2.743354e-002
7174, -9.982746e-002, 1.183562e-001, 2.743354e-002
7175, -9.964929e-002, 1.173699e-001, 2.743354e-002
7176, -9.947112e-002, 1.163836e-001, 2.743354e-002
7177, -9.929294e-002, 1.153973e-001, 2.743354e-002
7178, -9.911477e-002, 1.144111e-001, 2.743354e-002
7179, -9.893660e-002, 1.134248e-001, 2.743354e-002
7180, -9.875843e-002, 1.124385e-001, 2.743354e-002
7181, -9.858025e-002, 1.114522e-001, 2.743354e-002
7182, -9.840208e-002, 1.104659e-001, 2.743354e-002
7183, -9.822391e-002, 1.094796e-001, 2.743354e-002
7184, -9.804573e-002, 1.084933e-001, 2.743354e-002
7185, -9.786756e-002, 1.075071e-001, 2.743354e-002
7186, -9.768939e-002, 1.065208e-001, 2.743354e-002
7187, -9.751122e-002, 1.055345e-001, 2.743354e-002
7188, -9.733304e-002, 1.045482e-001, 2.743354e-002
7189, -9.715487e-002, 1.035619e-001, 2.743354e-002
7190, -9.697670e-002, 1.025756e-001, 2.743354e-002
7191, -9.679853e-002, 1.015894e-001, 2.743354e-002
7192, -9.662035e-002, 1.006031e-001, 2.743354e-002
7193, -9.644218e-002, 9.961679e-002, 2.743354e-002
7194, -9.626401e-002, 9.863051e-002, 2.743354e-002
7195, -9.608584e-002, 9.764422e-002, 2.743354e-002
7196, -9.590766e-002, 9.665794e-002, 2.743354e-002
7197, -9.572949e-002, 9.567165e-002, 2.743354e-002
7198, -9.555132e-002, 9.468537e-002, 2.743354e-002
7199, -9.537315e-002, 9.369909e-002, 2.743354e-002
7200, -9.519497e-002, 9.271280e-002, 2.743354e-002
7201, -9.501680e-002, 9.172652e-002, 2.743354e-002
7202, -9.483863e-002, 9.074023e-002, 2.743354e-002
7203, -9.466046e-002, 8.975395e-002, 2.743354e-002
7204, -9.448228e-002, 8.876767e-002, 2.743354e-002
7205, -9.430411e-002, 8.778138e-002, 2.743354e-002
7206, -9.412594e-002, 8.679510e-002, 2.743354e-002
7207, -9.394777e-002, 8.580881e-002, 2.743354e-002
7208, -9.376959e-002, 8.482253e-002, 2.743354e-002
7209, -9.359142e-002, 8.383624e-002, 2.743354e-002
7210, -9.341325e-002, 8.284996e-002, 2.743354e-002
7211, -9.323508e-002, 8.186368e-002, 2.743354e-002
7212, -9.305690e-002, 8.087739e-002, 2.743354e-002
7213, -9.287873e-002, 7.989111e-002, 2.743354e-002
7214, -9.270056e-002, 7.890482e-002, 2.743354e-002
7215, -9.252239e-002, 7.791854e-002, 2.743354e-002
7216, -9.234421e-002, 7.693226e-002, 2.743354e-002
7217, -9.216604e-002, 7.594597e-002, 2.743354e-002
7218, -9.198787e-002, 7.495969e-002, 2.743354e-002
7219, -9.180969e-002, 7.397340e-002, 2.743354e-002
7220, -9.163152e-002, 7.298712e-002, 2.743354e-002
7221, -9.145335e-002, 7.200084e-002, 2.743354e-002
7222, -9.127518e-002, 7.101455e-002, 2.743354e-002
7223, -9.109700e-002, 7.002827e-002, 2.743354e-002
7224, -9.091883e-002, 6.904198e-002, 2.743354e-002
7225, -9.074066e-002, 6.805570e-002, 2.743354e-002
7226, -9.056249e-002, 6.706941e-002, 2.743354e-002
7227, -9.038431e-002, 6.608313e-002, 2.743354e-002
7228, -9.020614e-002, 6.509685e-002, 2.743354e-002
7229, -9.002797e-002, 6.411056e-002, 2.743354e-002
7230, -8.984980e-002, 6.312428e-002, 2.743354e-002
7231, -8.967162e-002, 6.213799e-002, 2.743354e-002
7232, -8.949345e-002, 6.115171e-002, 2.743354e-002
7233, -8.931528e-002, 6.016543e-002, 2.743354e-002
7234, -8.913711e-002, 5.917914e-002, 2.743354e-002
7235, -8.895893e-002, 5.819286e-002, 2.743354e-002
7236, -8.878076e-002, 5.720657e-002, 2.743354e-002
7237, -8.860259e-002, 5.622029e-002, 2.743354e-002
7238, -8.842442e-002, 5.523400e-002, 2.743354e-002
7239, -8.824624e-002, 5.424772e-002, 2.743354e-002
7240, -8.806807e-002, 5.326144e-002, 2.743354e-002
7241, -8.788990e-002, 5.227515e-002, 2.743354e-002
7242, -8.771173e-002, 5.128887e-002, 2.743354e-002
7243, -8.753355e-002, 5.030258e-002, 2.743354e-002
7244, -8.735538e-002, 4.931630e-002, 2.743354e-002
7245, -8.717721e-002, 4.833002e-002, 2.743354e-002
7246, -8.699904e-002, 4.734373e-002, 2.743354e-002
7247, -8.682086e-002, 4.635745e-002, 2.743354e-002
7248, -8.664269e-002, 4.537116e-002, 2.743354e-002
7249, -8.646452e-002, 4.438488e-002, 2.743354e-002
7250, -8.628635e-002, 4.339859e-002, 2.743354e-002
7251, -8.610817e-002, 4.241231e-002, 2.743354e-002
7252, -8.593000e-002, 4.142603e-002, 2.743354e-002
7253, -8.575183e-002, 4.043974e-002, 2.743354e-002
7254, -8.557366e-002, 3.945346e-002, 2.743354e-002
7255, -8.539548e-002, 3.846717e-002, 2.743354e-002
7256, -8.521731e-002, 3.748089e-002, 2.743354e-002
7257, -8.503914e-002, 3.649461e-002, 2.743354e-002
7258, -8.486096e-002, 3.550832e-002, 2.743354e-002
7259, -8.468279e-002, 3.452204e-002, 2.743354e-002
7260, -8.450462e-002, 3.353575e-002, 2.743354e-002
7261, -8.432645e-002, 3.254947e-002, 2.743354e-002
7262, -8.414827e-002, 3.156318e-002, 2.743354e-002
7263, -8.397010e-002, 3.057690e-002, 2.743354e-002
7264, -8.379193e-002, 2.959062e-002, 2.743354e-002
7265, -8.361376e-002, 2.860433e-002, 2.743354e-002
7266, -8.343558e-002, 2.761805e-002, 2.743354e-002
7267, -8.325741e-002, 2.663176e-002, 2.743354e-002
7268, -8.307924e-002, 2.564548e-002, 2.743354e-002
7269, -8.290107e-002, 2.465919e-002, 2.743354e-002
7270, -8.272285e-002, 2.367282e-002, 2.743386e-002
7271, -8.254446e-002, 2.268618e-002, 2.743538e-002
7272, -8.236581e-002, 2.169912e-002, 2.743898e-002
7273, -8.218686e-002, 2.071164e-002, 2.744483e-002
7274, -8.200772e-002, 1.972392e-002, 2.745244e-002
7275, -8.182851e-002, 1.873624e-002, 2.746085e-002
7276, -8.164941e-002, 1.774889e-002, 2.746902e-002
7277, -1.069543e-001, 1.578076e-001, 2.743409e-002
7278, -1.053508e-001, 1.489310e-001, 2.743354e-002
7279, -8.850823e-002, 1.649875e-002, 2.208314e-002
7280, -8.753652e-002, 1.667425e-002, 2.200001e-002
7281, -1.081980e-001, 1.647138e-001, 2.747637e-002
7282, -9.247602e-002, 1.578516e-002, 2.472415e-002
7283, -9.187804e-002, 1.589146e-002, 2.394187e-002
7284, -1.071324e-001, 1.587940e-001, 2.743571e-002
7285, -9.341516e-002, 1.562292e-002, 2.750842e-002
7286, -1.051726e-001, 1.479447e-001, 2.743354e-002
7287, -1.073102e-001, 1.597804e-001, 2.743902e-002
7288, -1.199642e-001, 1.625883e-001, 2.750453e-002
7289, -1.197859e-001, 1.616012e-001, 2.750453e-002
7290, -1.196076e-001, 1.606145e-001, 2.750452e-002
7291, -1.194294e-001, 1.596280e-001, 2.750452e-002
7292, -1.192512e-001, 1.586416e-001, 2.750452e-002
7293, -1.190730e-001, 1.576553e-001, 2.750452e-002
7294, -1.188949e-001, 1.566690e-001, 2.750452e-002
7295, -1.187167e-001, 1.556827e-001, 2.750452e-002
7296, -1.185385e-001, 1.546964e-001, 2.750452e-002
7297, -1.183603e-001, 1.537101e-001, 2.750452e-002
7298, -1.181822e-001, 1.527238e-001, 2.750452e-002
7299, -1.180040e-001, 1.517376e-001, 2.750452e-002
7300, -1.178258e-001, 1.507513e-001, 2.750452e-002
7301, -1.176476e-001, 1.497650e-001, 2.750452e-002
7302, -1.174695e-001, 1.487787e-001, 2.750452e-002
7303, -1.172913e-001, 1.477924e-001, 2.750452e-002
7304, -1.171131e-001, 1.468061e-001, 2.750452e-002
7305, -1.169350e-001, 1.458198e-001, 2.750452e-002
7306, -1.167568e-001, 1.448336e-001, 2.750452e-002
7307, -1.165786e-001, 1.438473e-001, 2.750452e-002
7308, -1.164004e-001, 1.428610e-001, 2.750452e-002
7309, -1.162223e-001, 1.418747e-001, 2.750452e-002
7310, -1.160441e-001, 1.408884e-001, 2.750452e-002
7311, -1.158659e-001, 1.399021e-001, 2.750452e-002
7312, -1.156877e-001, 1.389159e-001, 2.750452e-002
7313, -1.155096e-001, 1.379296e-001, 2.750452e-002
7314, -1.153314e-001, 1.369433e-001, 2.750452e-002
7315, -1.151532e-001, 1.359570e-001, 2.750452e-002
7316, -1.149751e-001, 1.349707e-001, 2.750452e-002
7317, -1.147969e-001, 1.339844e-001, 2.750452e-002
7318, -1.146187e-001, 1.329982e-001, 2.750452e-002
7319, -1.144405e-001, 1.320119e-001, 2.750452e-002
7320, -1.142624e-001, 1.310256e-001, 2.750452e-002
7321, -1.140842e-001, 1.300393e-001, 2.750452e-002
7322, -1.139060e-001, 1.290530e-001, 2.750452e-002
7323, -1.137279e-001, 1.280667e-001, 2.750452e-002
7324, -1.135497e-001, 1.270804e-001, 2.750452e-002
7325, -1.133715e-001, 1.260942e-001, 2.750452e-002
7326, -1.131933e-001, 1.251079e-001, 2.750452e-002
7327, -1.130152e-001, 1.241216e-001, 2.750452e-002
7328, -1.128370e-001, 1.231353e-001, 2.750452e-002
7329, -1.126588e-001, 1.221490e-001, 2.750452e-002
7330, -1.124806e-001, 1.211627e-001, 2.750452e-002
7331, -1.123025e-001, 1.201765e-001, 2.750452e-002
7332, -1.121243e-001, 1.191902e-001, 2.750452e-002
7333, -1.119461e-001, 1.182039e-001, 2.750452e-002
7334, -1.117680e-001, 1.172176e-001, 2.750452e-002
7335, -1.115898e-001, 1.162313e-001, 2.750452e-002
7336, -1.114116e-001, 1.152450e-001, 2.750452e-002
7337, -1.112334e-001, 1.142588e-001, 2.750452e-002
7338, -1.110553e-001, 1.132725e-001, 2.750452e-002
7339, -1.108771e-001, 1.122862e-001, 2.750452e-002
7340, -1.106989e-001, 1.112999e-001, 2.750452e-002
7341, -1.105207e-001, 1.103136e-001, 2.750452e-002
7342, -1.103426e-001, 1.093273e-001, 2.750452e-002
7343, -1.101644e-001, 1.083410e-001, 2.750452e-002
7344, -1.099862e-001, 1.073548e-001, 2.750452e-002
7345, -1.098081e-001, 1.063685e-001, 2.750452e-002
7346, -1.096299e-001, 1.053822e-001, 2.750452e-002
7347, -1.094517e-001, 1.043959e-001, 2.750452e-002
7348, -1.092735e-001, 1.034096e-001, 2.750452e-002
7349, -1.090954e-001, 1.024233e-001, 2.750452e-002
7350, -1.089172e-001, 1.014371e-001, 2.750452e-002
7351, -1.087390e-001, 1.004508e-001, 2.750452e-002
7352, -1.085608e-001, 9.946449e-002, 2.750452e-002
7353, -1.083827e-001, 9.847821e-002, 2.750452e-002
7354, -1.082045e-001, 9.749192e-002, 2.750452e-002
7355, -1.080263e-001, 9.650564e-002, 2.750452e-002
7356, -1.078482e-001, 9.551936e-002, 2.750452e-002
7357, -1.076700e-001, 9.453307e-002, 2.750452e-002
7358, -1.074918e-001, 9.354679e-002, 2.750452e-002
7359, -1.073136e-001, 9.256050e-002, 2.750452e-002
7360, -1.071355e-001, 9.157422e-002, 2.750452e-002
7361, -1.069573e-001, 9.058794e-002, 2.750452e-002
7362, -1.067791e-001, 8.960165e-002, 2.750452e-002
7363, -1.066009e-001, 8.861537e-002, 2.750452e-002
7364, -1.064228e-001, 8.762908e-002, 2.750452e-002
7365, -1.062446e-001, 8.664280e-002, 2.750452e-002
7366, -1.060664e-001, 8.565651e-002, 2.750452e-002
7367, -1.058883e-001, 8.467023e-002, 2.750452e-002
7368, -1.057101e-001, 8.368395e-002, 2.750452e-002
7369, -1.055319e-001, 8.269766e-002, 2.750452e-002
7370, -1.053537e-001, 8.171138e-002, 2.750452e-002
7371, -1.051756e-001, 8.072509e-002, 2.750452e-002
7372, -1.049974e-001, 7.973881e-002, 2.750452e-002
7373, -1.048192e-001, 7.875253e-002, 2.750452e-002
7374, -1.046410e-001, 7.776624e-002, 2.750452e-002
7375, -1.044629e-001, 7.677996e-002, 2.750452e-002
7376, -1.042847e-001, 7.579367e-002, 2.750452e-002
7377, -1.041065e-001, 7.480739e-002, 2.750452e-002
7378, -1.039284e-001, 7.382110e-002, 2.750452e-002
7379, -1.037502e-001, 7.283482e-002, 2.750452e-002
7380, -1.035720e-001, 7.184854e-002, 2.750452e-002
7381, -1.033938e-001, 7.086225e-002, 2.750452e-002
7382, -1.032157e-001, 6.987597e-002, 2.750452e-002
7383, -1.030375e-001, 6.888968e-002, 2.750452e-002
7384, -1.028593e-001, 6.790340e-002, 2.750452e-002
7385, -1.026812e-001, 6.691712e-002, 2.750452e-002
7386, -1.025030e-001, 6.593083e-002, 2.750452e-002
7387, -1.023248e-001, 6.494455e-002, 2.750452e-002
7388, -1.021466e-001, 6.395826e-002, 2.750452e-002
7389, -1.019685e-001, 6.297198e-002, 2.750452e-002
7390, -1.017903e-001, 6.198569e-002, 2.750452e-002
7391, -1.016121e-001, 6.099941e-002, 2.750452e-002
7392, -1.014339e-001, 6.001313e-002, 2.750452e-002
7393, -1.012558e-001, 5.902684e-002, 2.750452e-002
7394, -1.010776e-001, 5.804056e-002, 2.750452e-002
7395, -1.008994e-001, 5.705427e-002, 2.750452e-002
7396, -1.007213e-001, 5.606799e-002, 2.750452e-002
7397, -1.005431e-001, 5.508171e-002, 2.750452e-002
7398, -1.003649e-001, 5.409542e-002, 2.750452e-002
7399, -1.001867e-001, 5.310914e-002, 2.750452e-002
7400, -1.000086e-001, 5.212285e-002, 2.750452e-002
7401, -9.983039e-002, 5.113657e-002, 2.750452e-002
7402, -9.965222e-002, 5.015029e-002, 2.750452e-002
7403, -9.947404e-002, 4.916400e-002, 2.750452e-002
7404, -9.929587e-002, 4.817772e-002, 2.750452e-002
7405, -9.911770e-002, 4.719143e-002, 2.750452e-002
7406, -9.893953e-002, 4.620515e-002, 2.750452e-002
7407, -9.876135e-002, 4.521886e-002, 2.750452e-002
7408, -9.858318e-002, 4.423258e-002, 2.750452e-002
7409, -9.840501e-002, 4.324630e-002, 2.750452e-002
7410, -9.822684e-002, 4.226001e-002, 2.750452e-002
7411, -9.804866e-002, 4.127373e-002, 2.750452e-002
7412, -9.787049e-002, 4.028744e-002, 2.750452e-002
7413, -9.769232e-002, 3.930116e-002, 2.750452e-002
7414, -9.751415e-002, 3.831488e-002, 2.750452e-002
7415, -9.733597e-002, 3.732859e-002, 2.750452e-002
7416, -9.715780e-002, 3.634231e-002, 2.750452e-002
7417, -9.697963e-002, 3.535602e-002, 2.750452e-002
7418, -9.680146e-002, 3.436974e-002, 2.750452e-002
7419, -9.662328e-002, 3.338345e-002, 2.750452e-002
7420, -9.644511e-002, 3.239717e-002, 2.750452e-002
7421, -9.626694e-002, 3.141089e-002, 2.750452e-002
7422, -9.608877e-002, 3.042460e-002, 2.750452e-002
7423, -9.591059e-002, 2.943832e-002, 2.750452e-002
7424, -9.573242e-002, 2.845203e-002, 2.750452e-002
7425, -9.555425e-002, 2.746575e-002, 2.750452e-002
7426, -9.537608e-002, 2.647947e-002, 2.750452e-002
7427, -9.519790e-002, 2.549318e-002, 2.750452e-002
7428, -9.501973e-002, 2.450690e-002, 2.750452e-002
7429, -9.484156e-002, 2.352061e-002, 2.750452e-002
7430, -9.466339e-002, 2.253433e-002, 2.750452e-002
7431, -9.448520e-002, 2.154798e-002, 2.750456e-002
7432, -9.430699e-002, 2.056137e-002, 2.750473e-002
7433, -9.412870e-002, 1.957424e-002, 2.750514e-002
7434, -9.395032e-002, 1.858653e-002, 2.750579e-002
7435, -9.377190e-002, 1.759848e-002, 2.750661e-002
7436, -9.359350e-002, 1.661051e-002, 2.750751e-002
7437, -9.116145e-002, 1.602005e-002, 2.326994e-002
7438, -1.083615e-001, 1.646841e-001, 2.650553e-002
7439, -1.086789e-001, 1.646266e-001, 2.557561e-002
7440, -1.091416e-001, 1.645428e-001, 2.471084e-002
7441, -1.097382e-001, 1.644348e-001, 2.393356e-002
7442, -1.104544e-001, 1.643055e-001, 2.326421e-002
7443, -1.112703e-001, 1.641586e-001, 2.272283e-002
7444, -1.121631e-001, 1.639978e-001, 2.232499e-002
7445, -1.131084e-001, 1.638275e-001, 2.208180e-002
7446, -1.140802e-001, 1.636523e-001, 2.200000e-002
7447, -1.150520e-001, 1.634767e-001, 2.208184e-002
7448, -1.159972e-001, 1.633056e-001, 2.232510e-002
7449, -1.168901e-001, 1.631437e-001, 2.272316e-002
7450, -1.177064e-001, 1.629957e-001, 2.326516e-002
7451, -1.184238e-001, 1.628658e-001, 2.393631e-002
7452, -1.190228e-001, 1.627578e-001, 2.471831e-002
7453, -1.194870e-001, 1.626743e-001, 2.558983e-002
7454, -1.198037e-001, 1.626173e-001, 2.652709e-002
7455, -1.078345e-001, 1.617226e-001, 2.647546e-002
7456, -1.080098e-001, 1.627095e-001, 2.648673e-002
7457, -1.051684e-001, 1.469270e-001, 2.645046e-002
7458, -1.053466e-001, 1.479133e-001, 2.645046e-002
7459, -9.311730e-002, 1.669149e-002, 2.559463e-002
7460, -9.265406e-002, 1.677242e-002, 2.472368e-002
7461, -9.343332e-002, 1.663714e-002, 2.653102e-002
7462, -1.055247e-001, 1.488996e-001, 2.645046e-002
7463, -1.057029e-001, 1.498859e-001, 2.645046e-002
7464, -9.052354e-002, 1.715161e-002, 2.272685e-002
7465, -8.963100e-002, 1.731248e-002, 2.232764e-002
7466, -9.133929e-002, 1.700527e-002, 2.326983e-002
7467, -8.277740e-002, 1.855594e-002, 2.469836e-002
7468, -8.231418e-002, 1.864310e-002, 2.555950e-002
7469, -1.076585e-001, 1.607362e-001, 2.646728e-002
7470, -8.579714e-002, 1.800479e-002, 2.232239e-002
7471, -8.490420e-002, 1.816640e-002, 2.271886e-002
7472, -1.048120e-001, 1.449544e-001, 2.645046e-002
7473, -1.049902e-001, 1.459407e-001, 2.645046e-002
7474, -1.065938e-001, 1.548173e-001, 2.645048e-002
7475, -1.067719e-001, 1.558036e-001, 2.645060e-002
7476, -1.058811e-001, 1.508721e-001, 2.645046e-002
7477, -1.060593e-001, 1.518584e-001, 2.645046e-002
7478, -1.046339e-001, 1.439682e-001, 2.645046e-002
7479, -1.081854e-001, 1.636967e-001, 2.649696e-002
7480, -1.062374e-001, 1.528447e-001, 2.645046e-002
7481, -1.064156e-001, 1.538310e-001, 2.645046e-002
7482, -1.042775e-001, 1.419956e-001, 2.645046e-002
7483, -1.044557e-001, 1.429819e-001, 2.645046e-002
7484, -1.040994e-001, 1.410093e-001, 2.645046e-002
7485, -1.039212e-001, 1.400230e-001, 2.645046e-002
7486, -1.037430e-001, 1.390367e-001, 2.645046e-002
7487, -1.035648e-001, 1.380505e-001, 2.645046e-002
7488, -1.033867e-001, 1.370642e-001, 2.645046e-002
7489, -1.032085e-001, 1.360779e-001, 2.645046e-002
7490, -1.030303e-001, 1.350916e-001, 2.645046e-002
7491, -1.028521e-001, 1.341053e-001, 2.645046e-002
7492, -1.026740e-001, 1.331190e-001, 2.645046e-002
7493, -1.024958e-001, 1.321327e-001, 2.645046e-002
7494, -1.023176e-001, 1.311465e-001, 2.645046e-002
7495, -1.021395e-001, 1.301602e-001, 2.645046e-002
7496, -1.019613e-001, 1.291739e-001, 2.645046e-002
7497, -1.017831e-001, 1.281876e-001, 2.645046e-002
7498, -1.016049e-001, 1.272013e-001, 2.645046e-002
7499, -1.014268e-001, 1.262150e-001, 2.645046e-002
7500, -1.012486e-001, 1.252288e-001, 2.645046e-002
7501, -1.010704e-001, 1.242425e-001, 2.645046e-002
7502, -1.008923e-001, 1.232562e-001, 2.645046e-002
7503, -1.007141e-001, 1.222699e-001, 2.645046e-002
7504, -1.005359e-001, 1.212836e-001, 2.645046e-002
7505, -1.003577e-001, 1.202973e-001, 2.645046e-002
7506, -1.001796e-001, 1.193111e-001, 2.645046e-002
7507, -1.000014e-001, 1.183248e-001, 2.645046e-002
7508, -9.982322e-002, 1.173385e-001, 2.645046e-002
7509, -9.964504e-002, 1.163522e-001, 2.645046e-002
7510, -9.946687e-002, 1.153659e-001, 2.645046e-002
7511, -9.928870e-002, 1.143796e-001, 2.645046e-002
7512, -9.911053e-002, 1.133933e-001, 2.645046e-002
7513, -9.893235e-002, 1.124071e-001, 2.645046e-002
7514, -9.875418e-002, 1.114208e-001, 2.645046e-002
7515, -9.857601e-002, 1.104345e-001, 2.645046e-002
7516, -9.839783e-002, 1.094482e-001, 2.645046e-002
7517, -9.821966e-002, 1.084619e-001, 2.645046e-002
7518, -9.804149e-002, 1.074756e-001, 2.645046e-002
7519, -9.786332e-002, 1.064894e-001, 2.645046e-002
7520, -9.768514e-002, 1.055031e-001, 2.645046e-002
7521, -9.750697e-002, 1.045168e-001, 2.645046e-002
7522, -9.732880e-002, 1.035305e-001, 2.645046e-002
7523, -9.715063e-002, 1.025442e-001, 2.645046e-002
7524, -9.697245e-002, 1.015579e-001, 2.645046e-002
7525, -9.679428e-002, 1.005717e-001, 2.645046e-002
7526, -9.661611e-002, 9.958537e-002, 2.645046e-002
7527, -9.643794e-002, 9.859909e-002, 2.645046e-002
7528, -9.625976e-002, 9.761280e-002, 2.645046e-002
7529, -9.608159e-002, 9.662652e-002, 2.645046e-002
7530, -9.590342e-002, 9.564023e-002, 2.645046e-002
7531, -9.572525e-002, 9.465395e-002, 2.645046e-002
7532, -9.554707e-002, 9.366767e-002, 2.645046e-002
7533, -9.536890e-002, 9.268138e-002, 2.645046e-002
7534, -9.519073e-002, 9.169510e-002, 2.645046e-002
7535, -9.501256e-002, 9.070881e-002, 2.645046e-002
7536, -9.483438e-002, 8.972253e-002, 2.645046e-002
7537, -9.465621e-002, 8.873625e-002, 2.645046e-002
7538, -9.447804e-002, 8.774996e-002, 2.645046e-002
7539, -9.429987e-002, 8.676368e-002, 2.645046e-002
7540, -9.412169e-002, 8.577739e-002, 2.645046e-002
7541, -9.394352e-002, 8.479111e-002, 2.645046e-002
7542, -9.376535e-002, 8.380482e-002, 2.645046e-002
7543, -9.358718e-002, 8.281854e-002, 2.645046e-002
7544, -9.340900e-002, 8.183226e-002, 2.645046e-002
7545, -9.323083e-002, 8.084597e-002, 2.645046e-002
7546, -9.305266e-002, 7.985969e-002, 2.645046e-002
7547, -9.287449e-002, 7.887340e-002, 2.645046e-002
7548, -9.269631e-002, 7.788712e-002, 2.645046e-002
7549, -9.251814e-002, 7.690084e-002, 2.645046e-002
7550, -9.233997e-002, 7.591455e-002, 2.645046e-002
7551, -9.216179e-002, 7.492827e-002, 2.645046e-002
7552, -9.198362e-002, 7.394198e-002, 2.645046e-002
7553, -9.180545e-002, 7.295570e-002, 2.645046e-002
7554, -9.162728e-002, 7.196941e-002, 2.645046e-002
7555, -9.144910e-002, 7.098313e-002, 2.645046e-002
7556, -9.127093e-002, 6.999685e-002, 2.645046e-002
7557, -9.109276e-002, 6.901056e-002, 2.645046e-002
7558, -9.091459e-002, 6.802428e-002, 2.645046e-002
7559, -9.073641e-002, 6.703799e-002, 2.645046e-002
7560, -9.055824e-002, 6.605171e-002, 2.645046e-002
7561, -9.038007e-002, 6.506543e-002, 2.645046e-002
7562, -9.020190e-002, 6.407914e-002, 2.645046e-002
7563, -9.002372e-002, 6.309286e-002, 2.645046e-002
7564, -8.984555e-002, 6.210657e-002, 2.645046e-002
7565, -8.966738e-002, 6.112029e-002, 2.645046e-002
7566, -8.948921e-002, 6.013401e-002, 2.645046e-002
7567, -8.931103e-002, 5.914772e-002, 2.645046e-002
7568, -8.913286e-002, 5.816144e-002, 2.645046e-002
7569, -8.895469e-002, 5.717515e-002, 2.645046e-002
7570, -8.877652e-002, 5.618887e-002, 2.645046e-002
7571, -8.859834e-002, 5.520258e-002, 2.645046e-002
7572, -8.842017e-002, 5.421630e-002, 2.645046e-002
7573, -8.824200e-002, 5.323002e-002, 2.645046e-002
7574, -8.806383e-002, 5.224373e-002, 2.645046e-002
7575, -8.788565e-002, 5.125745e-002, 2.645046e-002
7576, -8.770748e-002, 5.027116e-002, 2.645046e-002
7577, -8.752931e-002, 4.928488e-002, 2.645046e-002
7578, -8.735114e-002, 4.829860e-002, 2.645046e-002
7579, -8.717296e-002, 4.731231e-002, 2.645046e-002
7580, -8.699479e-002, 4.632603e-002, 2.645046e-002
7581, -8.681662e-002, 4.533974e-002, 2.645046e-002
7582, -8.663845e-002, 4.435346e-002, 2.645046e-002
7583, -8.646027e-002, 4.336717e-002, 2.645046e-002
7584, -8.628210e-002, 4.238089e-002, 2.645046e-002
7585, -8.610393e-002, 4.139461e-002, 2.645046e-002
7586, -8.592576e-002, 4.040832e-002, 2.645046e-002
7587, -8.574758e-002, 3.942204e-002, 2.645046e-002
7588, -8.556941e-002, 3.843575e-002, 2.645046e-002
7589, -8.539124e-002, 3.744947e-002, 2.645046e-002
7590, -8.521306e-002, 3.646319e-002, 2.645046e-002
7591, -8.503489e-002, 3.547690e-002, 2.645046e-002
7592, -8.485672e-002, 3.449062e-002, 2.645046e-002
7593, -8.467855e-002, 3.350433e-002, 2.645046e-002
7594, -8.450037e-002, 3.251805e-002, 2.645046e-002
7595, -8.432220e-002, 3.153176e-002, 2.645046e-002
7596, -8.414403e-002, 3.054548e-002, 2.645046e-002
7597, -8.396586e-002, 2.955920e-002, 2.645046e-002
7598, -8.378768e-002, 2.857291e-002, 2.645046e-002
7599, -8.360951e-002, 2.758663e-002, 2.645046e-002
7600, -8.343134e-002, 2.660034e-002, 2.645046e-002
7601, -8.325317e-002, 2.561406e-002, 2.645046e-002
7602, -8.307493e-002, 2.462772e-002, 2.645066e-002
7603, -8.289635e-002, 2.364115e-002, 2.645195e-002
7604, -8.271706e-002, 2.265412e-002, 2.645561e-002
7605, -8.253694e-002, 2.166665e-002, 2.646201e-002
7606, -8.235625e-002, 2.067893e-002, 2.647043e-002
7607, -8.217532e-002, 1.969121e-002, 2.647975e-002
7608, -8.199449e-002, 1.870378e-002, 2.648899e-002
7609, -9.205600e-002, 1.687780e-002, 2.394163e-002
7610, -8.771433e-002, 1.765837e-002, 2.200001e-002
7611, -8.674256e-002, 1.783393e-002, 2.208050e-002
7612, -1.071279e-001, 1.577766e-001, 2.645223e-002
7613, -1.073052e-001, 1.587636e-001, 2.645584e-002
7614, -1.074819e-001, 1.597502e-001, 2.646159e-002
7615, -8.868601e-002, 1.748298e-002, 2.208313e-002
7616, -8.408856e-002, 1.831448e-002, 2.325850e-002
7617, -1.069500e-001, 1.567901e-001, 2.645115e-002
7618, -1.196254e-001, 1.616302e-001, 2.652709e-002
7619, -1.194471e-001, 1.606435e-001, 2.652709e-002
7620, -1.192689e-001, 1.596570e-001, 2.652709e-002
7621, -1.190907e-001, 1.586707e-001, 2.652709e-002
7622, -1.189125e-001, 1.576844e-001, 2.652709e-002
7623, -1.187344e-001, 1.566981e-001, 2.652709e-002
7624, -1.185562e-001, 1.557117e-001, 2.652709e-002
7625, -1.183780e-001, 1.547254e-001, 2.652709e-002
7626, -1.181998e-001, 1.537391e-001, 2.652709e-002
7627, -1.180217e-001, 1.527528e-001, 2.652709e-002
7628, -1.178435e-001, 1.517665e-001, 2.652709e-002
7629, -1.176653e-001, 1.507803e-001, 2.652709e-002
7630, -1.174871e-001, 1.497940e-001, 2.652709e-002
7631, -1.173090e-001, 1.488077e-001, 2.652709e-002
7632, -1.171308e-001, 1.478214e-001, 2.652709e-002
7633, -1.169526e-001, 1.468351e-001, 2.652709e-002
7634, -1.167744e-001, 1.458488e-001, 2.652709e-002
7635, -1.165963e-001, 1.448626e-001, 2.652709e-002
7636, -1.164181e-001, 1.438763e-001, 2.652709e-002
7637, -1.162399e-001, 1.428900e-001, 2.652709e-002
7638, -1.160618e-001, 1.419037e-001, 2.652709e-002
7639, -1.158836e-001, 1.409174e-001, 2.652709e-002
7640, -1.157054e-001, 1.399311e-001, 2.652709e-002
7641, -1.155272e-001, 1.389449e-001, 2.652709e-002
7642, -1.153491e-001, 1.379586e-001, 2.652709e-002
7643, -1.151709e-001, 1.369723e-001, 2.652709e-002
7644, -1.149927e-001, 1.359860e-001, 2.652709e-002
7645, -1.148146e-001, 1.349997e-001, 2.652709e-002
7646, -1.146364e-001, 1.340134e-001, 2.652709e-002
7647, -1.144582e-001, 1.330271e-001, 2.652709e-002
7648, -1.142800e-001, 1.320409e-001, 2.652709e-002
7649, -1.141019e-001, 1.310546e-001, 2.652709e-002
7650, -1.139237e-001, 1.300683e-001, 2.652709e-002
7651, -1.137455e-001, 1.290820e-001, 2.652709e-002
7652, -1.135673e-001, 1.280957e-001, 2.652709e-002
7653, -1.133892e-001, 1.271094e-001, 2.652709e-002
7654, -1.132110e-001, 1.261232e-001, 2.652709e-002
7655, -1.130328e-001, 1.251369e-001, 2.652709e-002
7656, -1.128547e-001, 1.241506e-001, 2.652709e-002
7657, -1.126765e-001, 1.231643e-001, 2.652709e-002
7658, -1.124983e-001, 1.221780e-001, 2.652709e-002
7659, -1.123201e-001, 1.211917e-001, 2.652709e-002
7660, -1.121420e-001, 1.202055e-001, 2.652709e-002
7661, -1.119638e-001, 1.192192e-001, 2.652709e-002
7662, -1.117856e-001, 1.182329e-001, 2.652709e-002
7663, -1.116074e-001, 1.172466e-001, 2.652709e-002
7664, -1.114293e-001, 1.162603e-001, 2.652709e-002
7665, -1.112511e-001, 1.152740e-001, 2.652709e-002
7666, -1.110729e-001, 1.142878e-001, 2.652709e-002
7667, -1.108948e-001, 1.133015e-001, 2.652709e-002
7668, -1.107166e-001, 1.123152e-001, 2.652709e-002
7669, -1.105384e-001, 1.113289e-001, 2.652709e-002
7670, -1.103602e-001, 1.103426e-001, 2.652709e-002
7671, -1.101821e-001, 1.093563e-001, 2.652709e-002
7672, -1.100039e-001, 1.083700e-001, 2.652709e-002
7673, -1.098257e-001, 1.073838e-001, 2.652709e-002
7674, -1.096475e-001, 1.063975e-001, 2.652709e-002
7675, -1.094694e-001, 1.054112e-001, 2.652709e-002
7676, -1.092912e-001, 1.044249e-001, 2.652709e-002
7677, -1.091130e-001, 1.034386e-001, 2.652709e-002
7678, -1.089349e-001, 1.024523e-001, 2.652709e-002
7679, -1.087567e-001, 1.014661e-001, 2.652709e-002
7680, -1.085785e-001, 1.004798e-001, 2.652709e-002
7681, -1.084003e-001, 9.949349e-002, 2.652709e-002
7682, -1.082222e-001, 9.850720e-002, 2.652709e-002
7683, -1.080440e-001, 9.752092e-002, 2.652709e-002
7684, -1.078658e-001, 9.653464e-002, 2.652709e-002
7685, -1.076876e-001, 9.554835e-002, 2.652709e-002
7686, -1.075095e-001, 9.456207e-002, 2.652709e-002
7687, -1.073313e-001, 9.357578e-002, 2.652709e-002
7688, -1.071531e-001, 9.258950e-002, 2.652709e-002
7689, -1.069750e-001, 9.160322e-002, 2.652709e-002
7690, -1.067968e-001, 9.061693e-002, 2.652709e-002
7691, -1.066186e-001, 8.963065e-002, 2.652709e-002
7692, -1.064404e-001, 8.864436e-002, 2.652709e-002
7693, -1.062623e-001, 8.765808e-002, 2.652709e-002
7694, -1.060841e-001, 8.667179e-002, 2.652709e-002
7695, -1.059059e-001, 8.568551e-002, 2.652709e-002
7696, -1.057278e-001, 8.469923e-002, 2.652709e-002
7697, -1.055496e-001, 8.371294e-002, 2.652709e-002
7698, -1.053714e-001, 8.272666e-002, 2.652709e-002
7699, -1.051932e-001, 8.174037e-002, 2.652709e-002
7700, -1.050151e-001, 8.075409e-002, 2.652709e-002
7701, -1.048369e-001, 7.976781e-002, 2.652709e-002
7702, -1.046587e-001, 7.878152e-002, 2.652709e-002
7703, -1.044805e-001, 7.779524e-002, 2.652709e-002
7704, -1.043024e-001, 7.680895e-002, 2.652709e-002
7705, -1.041242e-001, 7.582267e-002, 2.652709e-002
7706, -1.039460e-001, 7.483638e-002, 2.652709e-002
7707, -1.037679e-001, 7.385010e-002, 2.652709e-002
7708, -1.035897e-001, 7.286382e-002, 2.652709e-002
7709, -1.034115e-001, 7.187753e-002, 2.652709e-002
7710, -1.032333e-001, 7.089125e-002, 2.652709e-002
7711, -1.030552e-001, 6.990496e-002, 2.652709e-002
7712, -1.028770e-001, 6.891868e-002, 2.652709e-002
7713, -1.026988e-001, 6.793240e-002, 2.652709e-002
7714, -1.025206e-001, 6.694611e-002, 2.652709e-002
7715, -1.023425e-001, 6.595983e-002, 2.652709e-002
7716, -1.021643e-001, 6.497354e-002, 2.652709e-002
7717, -1.019861e-001, 6.398726e-002, 2.652709e-002
7718, -1.018080e-001, 6.300097e-002, 2.652709e-002
7719, -1.016298e-001, 6.201469e-002, 2.652709e-002
7720, -1.014516e-001, 6.102841e-002, 2.652709e-002
7721, -1.012734e-001, 6.004212e-002, 2.652709e-002
7722, -1.010953e-001, 5.905584e-002, 2.652709e-002
7723, -1.009171e-001, 5.806955e-002, 2.652709e-002
7724, -1.007389e-001, 5.708327e-002, 2.652709e-002
7725, -1.005607e-001, 5.609699e-002, 2.652709e-002
7726, -1.003826e-001, 5.511070e-002, 2.652709e-002
7727, -1.002044e-001, 5.412442e-002, 2.652709e-002
7728, -1.000262e-001, 5.313813e-002, 2.652709e-002
7729, -9.984806e-002, 5.215185e-002, 2.652709e-002
7730, -9.966988e-002, 5.116556e-002, 2.652709e-002
7731, -9.949171e-002, 5.017928e-002, 2.652709e-002
7732, -9.931354e-002, 4.919300e-002, 2.652709e-002
7733, -9.913537e-002, 4.820671e-002, 2.652709e-002
7734, -9.895719e-002, 4.722043e-002, 2.652709e-002
7735, -9.877902e-002, 4.623414e-002, 2.652709e-002
7736, -9.860085e-002, 4.524786e-002, 2.652709e-002
7737, -9.842267e-002, 4.426158e-002, 2.652709e-002
7738, -9.824450e-002, 4.327529e-002, 2.652709e-002
7739, -9.806633e-002, 4.228901e-002, 2.652709e-002
7740, -9.788816e-002, 4.130272e-002, 2.652709e-002
7741, -9.770998e-002, 4.031644e-002, 2.652709e-002
7742, -9.753181e-002, 3.933016e-002, 2.652709e-002
7743, -9.735364e-002, 3.834387e-002, 2.652709e-002
7744, -9.717547e-002, 3.735759e-002, 2.652709e-002
7745, -9.699729e-002, 3.637130e-002, 2.652709e-002
7746, -9.681912e-002, 3.538502e-002, 2.652709e-002
7747, -9.664095e-002, 3.439873e-002, 2.652709e-002
7748, -9.646278e-002, 3.341245e-002, 2.652709e-002
7749, -9.628460e-002, 3.242617e-002, 2.652709e-002
7750, -9.610643e-002, 3.143988e-002, 2.652709e-002
7751, -9.592826e-002, 3.045360e-002, 2.652709e-002
7752, -9.575009e-002, 2.946731e-002, 2.652709e-002
7753, -9.557191e-002, 2.848103e-002, 2.652709e-002
7754, -9.539374e-002, 2.749475e-002, 2.652709e-002
7755, -9.521557e-002, 2.650846e-002, 2.652709e-002
7756, -9.503740e-002, 2.552218e-002, 2.652709e-002
7757, -9.485922e-002, 2.453589e-002, 2.652709e-002
7758, -9.468105e-002, 2.354961e-002, 2.652709e-002
7759, -9.450288e-002, 2.256329e-002, 2.652710e-002
7760, -9.432469e-002, 2.157677e-002, 2.652722e-002
7761, -9.414649e-002, 2.058979e-002, 2.652759e-002
7762, -9.396826e-002, 1.960216e-002, 2.652831e-002
7763, -9.378997e-002, 1.861391e-002, 2.652924e-002
7764, -9.361164e-002, 1.762540e-002, 2.653019e-002
7765, -8.337349e-002, 1.844544e-002, 2.392474e-002
7766, -1.085040e-001, 1.636391e-001, 2.556790e-002
7767, -1.089669e-001, 1.635553e-001, 2.470537e-002
7768, -1.095624e-001, 1.634477e-001, 2.393087e-002
7769, -1.102776e-001, 1.633190e-001, 2.326311e-002
7770, -1.110930e-001, 1.631728e-001, 2.272237e-002
7771, -1.119857e-001, 1.630130e-001, 2.232481e-002
7772, -1.129309e-001, 1.628434e-001, 2.208175e-002
7773, -1.139027e-001, 1.626686e-001, 2.200000e-002
7774, -1.148744e-001, 1.624929e-001, 2.208186e-002
7775, -1.158194e-001, 1.623213e-001, 2.232512e-002
7776, -1.167122e-001, 1.621585e-001, 2.272317e-002
7777, -1.175283e-001, 1.620096e-001, 2.326516e-002
7778, -1.182456e-001, 1.618793e-001, 2.393631e-002
7779, -1.188445e-001, 1.617710e-001, 2.471831e-002
7780, -1.193087e-001, 1.616873e-001, 2.558983e-002
7781, -1.055004e-001, 1.468670e-001, 2.551032e-002
7782, -1.056786e-001, 1.478533e-001, 2.551032e-002
7783, -1.049659e-001, 1.439082e-001, 2.551032e-002
7784, -1.051441e-001, 1.448945e-001, 2.551032e-002
7785, -8.692084e-002, 1.881813e-002, 2.208042e-002
7786, -8.597633e-002, 1.898912e-002, 2.232192e-002
7787, -1.058567e-001, 1.488396e-001, 2.551032e-002
7788, -1.060349e-001, 1.498259e-001, 2.551032e-002
7789, -8.249657e-002, 1.963021e-002, 2.555053e-002
7790, -9.151707e-002, 1.799172e-002, 2.326951e-002
7791, -9.070117e-002, 1.813712e-002, 2.272664e-002
7792, -8.296114e-002, 1.954257e-002, 2.469015e-002
7793, -1.079830e-001, 1.606789e-001, 2.553758e-002
7794, -1.081563e-001, 1.616652e-001, 2.554814e-002
7795, -8.508429e-002, 1.915090e-002, 2.271767e-002
7796, -1.053222e-001, 1.458807e-001, 2.551032e-002
7797, -1.062131e-001, 1.508122e-001, 2.551032e-002
7798, -1.063913e-001, 1.517985e-001, 2.551032e-002
7799, -9.329556e-002, 1.768019e-002, 2.559386e-002
7800, -8.427007e-002, 1.929942e-002, 2.325577e-002
7801, -8.980865e-002, 1.829728e-002, 2.232755e-002
7802, -8.886374e-002, 1.846736e-002, 2.208312e-002
7803, -1.065694e-001, 1.527847e-001, 2.551032e-002
7804, -1.067476e-001, 1.537710e-001, 2.551033e-002
7805, -1.042532e-001, 1.399630e-001, 2.551032e-002
7806, -1.044314e-001, 1.409493e-001, 2.551032e-002
7807, -1.046095e-001, 1.419356e-001, 2.551032e-002
7808, -1.038968e-001, 1.379905e-001, 2.551032e-002
7809, -1.040750e-001, 1.389768e-001, 2.551032e-002
7810, -1.037187e-001, 1.370042e-001, 2.551032e-002
7811, -1.035405e-001, 1.360179e-001, 2.551032e-002
7812, -1.033623e-001, 1.350316e-001, 2.551032e-002
7813, -1.031842e-001, 1.340453e-001, 2.551032e-002
7814, -1.030060e-001, 1.330591e-001, 2.551032e-002
7815, -1.028278e-001, 1.320728e-001, 2.551032e-002
7816, -1.026496e-001, 1.310865e-001, 2.551032e-002
7817, -1.024715e-001, 1.301002e-001, 2.551032e-002
7818, -1.022933e-001, 1.291139e-001, 2.551032e-002
7819, -1.021151e-001, 1.281276e-001, 2.551032e-002
7820, -1.019369e-001, 1.271413e-001, 2.551032e-002
7821, -1.017588e-001, 1.261551e-001, 2.551032e-002
7822, -1.015806e-001, 1.251688e-001, 2.551032e-002
