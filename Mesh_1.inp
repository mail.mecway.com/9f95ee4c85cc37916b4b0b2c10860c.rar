20226, 18875, 18950, 18949, 18876, 
20227, 18831, 18952, 18951, 18830, 
20228, 18832, 18953, 18952, 18831, 
20229, 18833, 18954, 18953, 18832, 
20230, 18834, 18955, 18954, 18833, 
20231, 18835, 18956, 18955, 18834, 
20232, 18836, 18957, 18956, 18835, 
20233, 18837, 18958, 18957, 18836, 
20234, 19034, 19029, 19030, 19032, 
20235, 18839, 18960, 18959, 18838, 
20236, 18840, 18961, 18960, 18839, 
20237, 18841, 18962, 18961, 18840, 
20238, 18842, 18963, 18962, 18841, 
20239, 18843, 18964, 18963, 18842, 
20240, 18844, 18965, 18964, 18843, 
20241, 18845, 18966, 18965, 18844, 
20242, 18846, 18967, 18966, 18845, 
20243, 18847, 18968, 18967, 18846, 
20244, 18895, 18896, 18993, 18916, 
20245, 18849, 18920, 18919, 18848, 
20246, 18850, 18921, 18920, 18849, 
20247, 18854, 18950, 18875, 18853, 
20248, 18855, 18970, 18950, 18854, 
20249, 18856, 18971, 18970, 18855, 
20250, 18857, 18972, 18971, 18856, 
20251, 18858, 18973, 18972, 18857, 
20252, 18859, 18974, 18973, 18858, 
20253, 18860, 18975, 18974, 18859, 
20254, 18861, 18976, 18975, 18860, 
20255, 18862, 18977, 18976, 18861, 
20256, 18891, 18991, 18992, 18892, 
20257, 18864, 18979, 18978, 18863, 
20258, 18884, 18826, 18827, 18885, 
20259, 18866, 18936, 18980, 18865, 
20260, 18867, 18935, 18936, 18866, 
20261, 18868, 18934, 18935, 18867, 
20262, 18869, 18933, 18934, 18868, 
20263, 18870, 18932, 18933, 18869, 
20264, 18872, 18981, 18932, 18871, 
20265, 18873, 18982, 18981, 18872, 
20266, 18874, 18929, 18982, 18873, 
20267, 18876, 18949, 18983, 18877, 
20268, 18877, 18983, 18984, 18878, 
20269, 18878, 18984, 18985, 18879, 
20270, 18879, 18985, 18947, 18880, 
