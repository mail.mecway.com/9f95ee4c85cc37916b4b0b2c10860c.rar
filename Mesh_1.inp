7823, -1.014024e-001, 1.241825e-001, 2.551032e-002
7824, -1.012243e-001, 1.231962e-001, 2.551032e-002
7825, -1.010461e-001, 1.222099e-001, 2.551032e-002
7826, -1.008679e-001, 1.212236e-001, 2.551032e-002
7827, -1.006897e-001, 1.202374e-001, 2.551032e-002
7828, -1.005116e-001, 1.192511e-001, 2.551032e-002
7829, -1.003334e-001, 1.182648e-001, 2.551032e-002
7830, -1.001552e-001, 1.172785e-001, 2.551032e-002
7831, -9.997705e-002, 1.162922e-001, 2.551032e-002
7832, -9.979888e-002, 1.153059e-001, 2.551032e-002
7833, -9.962071e-002, 1.143197e-001, 2.551032e-002
7834, -9.944253e-002, 1.133334e-001, 2.551032e-002
7835, -9.926436e-002, 1.123471e-001, 2.551032e-002
7836, -9.908619e-002, 1.113608e-001, 2.551032e-002
7837, -9.890802e-002, 1.103745e-001, 2.551032e-002
7838, -9.872984e-002, 1.093882e-001, 2.551032e-002
7839, -9.855167e-002, 1.084020e-001, 2.551032e-002
7840, -9.837350e-002, 1.074157e-001, 2.551032e-002
7841, -9.819533e-002, 1.064294e-001, 2.551032e-002
7842, -9.801715e-002, 1.054431e-001, 2.551032e-002
7843, -9.783898e-002, 1.044568e-001, 2.551032e-002
7844, -9.766081e-002, 1.034705e-001, 2.551032e-002
7845, -9.748264e-002, 1.024842e-001, 2.551032e-002
7846, -9.730446e-002, 1.014980e-001, 2.551032e-002
7847, -9.712629e-002, 1.005117e-001, 2.551032e-002
7848, -9.694812e-002, 9.952539e-002, 2.551032e-002
7849, -9.676995e-002, 9.853911e-002, 2.551032e-002
7850, -9.659177e-002, 9.755283e-002, 2.551032e-002
7851, -9.641360e-002, 9.656654e-002, 2.551032e-002
7852, -9.623543e-002, 9.558026e-002, 2.551032e-002
7853, -9.605726e-002, 9.459397e-002, 2.551032e-002
7854, -9.587908e-002, 9.360769e-002, 2.551032e-002
7855, -9.570091e-002, 9.262140e-002, 2.551032e-002
7856, -9.552274e-002, 9.163512e-002, 2.551032e-002
7857, -9.534456e-002, 9.064884e-002, 2.551032e-002
7858, -9.516639e-002, 8.966255e-002, 2.551032e-002
7859, -9.498822e-002, 8.867627e-002, 2.551032e-002
7860, -9.481005e-002, 8.768998e-002, 2.551032e-002
7861, -9.463187e-002, 8.670370e-002, 2.551032e-002
7862, -9.445370e-002, 8.571742e-002, 2.551032e-002
7863, -9.427553e-002, 8.473113e-002, 2.551032e-002
7864, -9.409736e-002, 8.374485e-002, 2.551032e-002
7865, -9.391918e-002, 8.275856e-002, 2.551032e-002
7866, -9.374101e-002, 8.177228e-002, 2.551032e-002
7867, -9.356284e-002, 8.078599e-002, 2.551032e-002
7868, -9.338467e-002, 7.979971e-002, 2.551032e-002
7869, -9.320649e-002, 7.881343e-002, 2.551032e-002
7870, -9.302832e-002, 7.782714e-002, 2.551032e-002
7871, -9.285015e-002, 7.684086e-002, 2.551032e-002
7872, -9.267198e-002, 7.585457e-002, 2.551032e-002
7873, -9.249380e-002, 7.486829e-002, 2.551032e-002
7874, -9.231563e-002, 7.388201e-002, 2.551032e-002
7875, -9.213746e-002, 7.289572e-002, 2.551032e-002
7876, -9.195929e-002, 7.190944e-002, 2.551032e-002
7877, -9.178111e-002, 7.092315e-002, 2.551032e-002
7878, -9.160294e-002, 6.993687e-002, 2.551032e-002
7879, -9.142477e-002, 6.895059e-002, 2.551032e-002
7880, -9.124660e-002, 6.796430e-002, 2.551032e-002
7881, -9.106842e-002, 6.697802e-002, 2.551032e-002
7882, -9.089025e-002, 6.599173e-002, 2.551032e-002
7883, -9.071208e-002, 6.500545e-002, 2.551032e-002
7884, -9.053391e-002, 6.401916e-002, 2.551032e-002
7885, -9.035573e-002, 6.303288e-002, 2.551032e-002
7886, -9.017756e-002, 6.204660e-002, 2.551032e-002
7887, -8.999939e-002, 6.106031e-002, 2.551032e-002
7888, -8.982122e-002, 6.007403e-002, 2.551032e-002
7889, -8.964304e-002, 5.908774e-002, 2.551032e-002
7890, -8.946487e-002, 5.810146e-002, 2.551032e-002
7891, -8.928670e-002, 5.711518e-002, 2.551032e-002
7892, -8.910853e-002, 5.612889e-002, 2.551032e-002
7893, -8.893035e-002, 5.514261e-002, 2.551032e-002
7894, -8.875218e-002, 5.415632e-002, 2.551032e-002
7895, -8.857401e-002, 5.317004e-002, 2.551032e-002
7896, -8.839583e-002, 5.218375e-002, 2.551032e-002
7897, -8.821766e-002, 5.119747e-002, 2.551032e-002
7898, -8.803949e-002, 5.021119e-002, 2.551032e-002
7899, -8.786132e-002, 4.922490e-002, 2.551032e-002
7900, -8.768314e-002, 4.823862e-002, 2.551032e-002
7901, -8.750497e-002, 4.725233e-002, 2.551032e-002
7902, -8.732680e-002, 4.626605e-002, 2.551032e-002
7903, -8.714863e-002, 4.527977e-002, 2.551032e-002
7904, -8.697045e-002, 4.429348e-002, 2.551032e-002
7905, -8.679228e-002, 4.330720e-002, 2.551032e-002
7906, -8.661411e-002, 4.232091e-002, 2.551032e-002
7907, -8.643594e-002, 4.133463e-002, 2.551032e-002
7908, -8.625776e-002, 4.034834e-002, 2.551032e-002
7909, -8.607959e-002, 3.936206e-002, 2.551032e-002
7910, -8.590142e-002, 3.837578e-002, 2.551032e-002
7911, -8.572325e-002, 3.738949e-002, 2.551032e-002
7912, -8.554507e-002, 3.640321e-002, 2.551032e-002
7913, -8.536690e-002, 3.541692e-002, 2.551032e-002
7914, -8.518873e-002, 3.443064e-002, 2.551032e-002
7915, -8.501056e-002, 3.344436e-002, 2.551032e-002
7916, -8.483238e-002, 3.245807e-002, 2.551032e-002
7917, -8.465421e-002, 3.147179e-002, 2.551032e-002
7918, -8.447604e-002, 3.048550e-002, 2.551032e-002
7919, -8.429787e-002, 2.949922e-002, 2.551032e-002
7920, -8.411969e-002, 2.851293e-002, 2.551032e-002
7921, -8.394152e-002, 2.752665e-002, 2.551032e-002
7922, -8.376335e-002, 2.654037e-002, 2.551032e-002
7923, -8.358512e-002, 2.555405e-002, 2.551043e-002
7924, -8.340653e-002, 2.456758e-002, 2.551126e-002
7925, -8.322681e-002, 2.358067e-002, 2.551435e-002
7926, -8.304536e-002, 2.259318e-002, 2.552099e-002
7927, -8.286259e-002, 2.160538e-002, 2.553038e-002
7928, -8.267941e-002, 2.061766e-002, 2.554076e-002
7929, -1.078088e-001, 1.596935e-001, 2.552931e-002
7930, -9.223401e-002, 1.786565e-002, 2.394115e-002
7931, -1.074588e-001, 1.577182e-001, 2.551433e-002
7932, -1.076342e-001, 1.587068e-001, 2.552120e-002
7933, -8.789229e-002, 1.864266e-002, 2.200001e-002
7934, -1.047877e-001, 1.429219e-001, 2.551032e-002
7935, -1.072816e-001, 1.567307e-001, 2.551171e-002
7936, -8.355676e-002, 1.943118e-002, 2.391922e-002
7937, -1.083298e-001, 1.626519e-001, 2.555868e-002
7938, -1.069258e-001, 1.547573e-001, 2.551039e-002
7939, -1.071038e-001, 1.557439e-001, 2.551075e-002
7940, -1.191305e-001, 1.607007e-001, 2.558983e-002
7941, -1.189523e-001, 1.597143e-001, 2.558983e-002
7942, -1.187741e-001, 1.587281e-001, 2.558983e-002
7943, -1.185960e-001, 1.577419e-001, 2.558982e-002
7944, -1.184178e-001, 1.567556e-001, 2.558982e-002
7945, -1.182396e-001, 1.557691e-001, 2.558982e-002
7946, -1.180614e-001, 1.547827e-001, 2.558983e-002
7947, -1.178832e-001, 1.537964e-001, 2.558983e-002
7948, -1.177050e-001, 1.528100e-001, 2.558983e-002
7949, -1.175268e-001, 1.518238e-001, 2.558983e-002
7950, -1.173487e-001, 1.508375e-001, 2.558983e-002
7951, -1.171705e-001, 1.498512e-001, 2.558983e-002
7952, -1.169923e-001, 1.488649e-001, 2.558983e-002
7953, -1.168142e-001, 1.478786e-001, 2.558983e-002
7954, -1.166360e-001, 1.468923e-001, 2.558983e-002
7955, -1.164578e-001, 1.459060e-001, 2.558983e-002
7956, -1.162796e-001, 1.449198e-001, 2.558983e-002
7957, -1.161015e-001, 1.439335e-001, 2.558983e-002
7958, -1.159233e-001, 1.429472e-001, 2.558983e-002
7959, -1.157451e-001, 1.419609e-001, 2.558983e-002
7960, -1.155670e-001, 1.409746e-001, 2.558983e-002
7961, -1.153888e-001, 1.399883e-001, 2.558983e-002
7962, -1.152106e-001, 1.390021e-001, 2.558983e-002
7963, -1.150324e-001, 1.380158e-001, 2.558983e-002
7964, -1.148543e-001, 1.370295e-001, 2.558983e-002
7965, -1.146761e-001, 1.360432e-001, 2.558983e-002
7966, -1.144979e-001, 1.350569e-001, 2.558983e-002
7967, -1.143197e-001, 1.340706e-001, 2.558983e-002
7968, -1.141416e-001, 1.330843e-001, 2.558983e-002
7969, -1.139634e-001, 1.320981e-001, 2.558983e-002
7970, -1.137852e-001, 1.311118e-001, 2.558983e-002
7971, -1.136071e-001, 1.301255e-001, 2.558983e-002
7972, -1.134289e-001, 1.291392e-001, 2.558983e-002
7973, -1.132507e-001, 1.281529e-001, 2.558983e-002
7974, -1.130725e-001, 1.271666e-001, 2.558983e-002
7975, -1.128944e-001, 1.261804e-001, 2.558983e-002
7976, -1.127162e-001, 1.251941e-001, 2.558983e-002
7977, -1.125380e-001, 1.242078e-001, 2.558983e-002
7978, -1.123598e-001, 1.232215e-001, 2.558983e-002
7979, -1.121817e-001, 1.222352e-001, 2.558983e-002
7980, -1.120035e-001, 1.212489e-001, 2.558983e-002
7981, -1.118253e-001, 1.202627e-001, 2.558983e-002
7982, -1.116472e-001, 1.192764e-001, 2.558983e-002
7983, -1.114690e-001, 1.182901e-001, 2.558983e-002
7984, -1.112908e-001, 1.173038e-001, 2.558983e-002
7985, -1.111126e-001, 1.163175e-001, 2.558983e-002
7986, -1.109345e-001, 1.153312e-001, 2.558983e-002
7987, -1.107563e-001, 1.143450e-001, 2.558983e-002
7988, -1.105781e-001, 1.133587e-001, 2.558983e-002
7989, -1.103999e-001, 1.123724e-001, 2.558983e-002
7990, -1.102218e-001, 1.113861e-001, 2.558983e-002
7991, -1.100436e-001, 1.103998e-001, 2.558983e-002
7992, -1.098654e-001, 1.094135e-001, 2.558983e-002
7993, -1.096873e-001, 1.084272e-001, 2.558983e-002
7994, -1.095091e-001, 1.074410e-001, 2.558983e-002
7995, -1.093309e-001, 1.064547e-001, 2.558983e-002
7996, -1.091527e-001, 1.054684e-001, 2.558983e-002
7997, -1.089746e-001, 1.044821e-001, 2.558983e-002
7998, -1.087964e-001, 1.034958e-001, 2.558983e-002
7999, -1.086182e-001, 1.025095e-001, 2.558983e-002
8000, -1.084400e-001, 1.015233e-001, 2.558983e-002
8001, -1.082619e-001, 1.005370e-001, 2.558983e-002
8002, -1.080837e-001, 9.955069e-002, 2.558983e-002
8003, -1.079055e-001, 9.856440e-002, 2.558983e-002
8004, -1.077274e-001, 9.757812e-002, 2.558983e-002
8005, -1.075492e-001, 9.659184e-002, 2.558983e-002
8006, -1.073710e-001, 9.560555e-002, 2.558983e-002
8007, -1.071928e-001, 9.461927e-002, 2.558983e-002
8008, -1.070147e-001, 9.363298e-002, 2.558983e-002
8009, -1.068365e-001, 9.264670e-002, 2.558983e-002
8010, -1.066583e-001, 9.166042e-002, 2.558983e-002
8011, -1.064801e-001, 9.067413e-002, 2.558983e-002
8012, -1.063020e-001, 8.968785e-002, 2.558983e-002
8013, -1.061238e-001, 8.870156e-002, 2.558983e-002
8014, -1.059456e-001, 8.771528e-002, 2.558983e-002
8015, -1.057675e-001, 8.672899e-002, 2.558983e-002
8016, -1.055893e-001, 8.574271e-002, 2.558983e-002
8017, -1.054111e-001, 8.475643e-002, 2.558983e-002
8018, -1.052329e-001, 8.377014e-002, 2.558983e-002
8019, -1.050548e-001, 8.278386e-002, 2.558983e-002
8020, -1.048766e-001, 8.179757e-002, 2.558983e-002
8021, -1.046984e-001, 8.081129e-002, 2.558983e-002
8022, -1.045203e-001, 7.982501e-002, 2.558983e-002
8023, -1.043421e-001, 7.883872e-002, 2.558983e-002
8024, -1.041639e-001, 7.785244e-002, 2.558983e-002
8025, -1.039857e-001, 7.686615e-002, 2.558983e-002
8026, -1.038076e-001, 7.587987e-002, 2.558983e-002
8027, -1.036294e-001, 7.489359e-002, 2.558983e-002
8028, -1.034512e-001, 7.390730e-002, 2.558983e-002
8029, -1.032730e-001, 7.292102e-002, 2.558983e-002
8030, -1.030949e-001, 7.193473e-002, 2.558983e-002
8031, -1.029167e-001, 7.094845e-002, 2.558983e-002
8032, -1.027385e-001, 6.996216e-002, 2.558983e-002
8033, -1.025604e-001, 6.897588e-002, 2.558983e-002
8034, -1.023822e-001, 6.798960e-002, 2.558983e-002
8035, -1.022040e-001, 6.700331e-002, 2.558983e-002
8036, -1.020258e-001, 6.601703e-002, 2.558983e-002
8037, -1.018477e-001, 6.503074e-002, 2.558983e-002
8038, -1.016695e-001, 6.404446e-002, 2.558983e-002
8039, -1.014913e-001, 6.305818e-002, 2.558983e-002
8040, -1.013131e-001, 6.207189e-002, 2.558983e-002
8041, -1.011350e-001, 6.108561e-002, 2.558983e-002
8042, -1.009568e-001, 6.009932e-002, 2.558983e-002
8043, -1.007786e-001, 5.911304e-002, 2.558983e-002
8044, -1.006005e-001, 5.812675e-002, 2.558983e-002
8045, -1.004223e-001, 5.714047e-002, 2.558983e-002
8046, -1.002441e-001, 5.615419e-002, 2.558983e-002
8047, -1.000659e-001, 5.516790e-002, 2.558983e-002
8048, -9.988776e-002, 5.418162e-002, 2.558983e-002
8049, -9.970959e-002, 5.319533e-002, 2.558983e-002
8050, -9.953142e-002, 5.220905e-002, 2.558983e-002
8051, -9.935325e-002, 5.122277e-002, 2.558983e-002
8052, -9.917507e-002, 5.023648e-002, 2.558983e-002
8053, -9.899690e-002, 4.925020e-002, 2.558983e-002
8054, -9.881873e-002, 4.826391e-002, 2.558983e-002
8055, -9.864056e-002, 4.727763e-002, 2.558983e-002
8056, -9.846238e-002, 4.629134e-002, 2.558983e-002
8057, -9.828421e-002, 4.530506e-002, 2.558983e-002
8058, -9.810604e-002, 4.431878e-002, 2.558983e-002
8059, -9.792787e-002, 4.333249e-002, 2.558983e-002
8060, -9.774969e-002, 4.234621e-002, 2.558983e-002
8061, -9.757152e-002, 4.135992e-002, 2.558983e-002
8062, -9.739335e-002, 4.037364e-002, 2.558983e-002
8063, -9.721518e-002, 3.938736e-002, 2.558983e-002
8064, -9.703700e-002, 3.840107e-002, 2.558983e-002
8065, -9.685883e-002, 3.741479e-002, 2.558983e-002
8066, -9.668066e-002, 3.642850e-002, 2.558983e-002
8067, -9.650249e-002, 3.544222e-002, 2.558983e-002
8068, -9.632431e-002, 3.445593e-002, 2.558983e-002
8069, -9.614614e-002, 3.346965e-002, 2.558983e-002
8070, -9.596797e-002, 3.248337e-002, 2.558983e-002
8071, -9.578979e-002, 3.149708e-002, 2.558983e-002
8072, -9.561162e-002, 3.051080e-002, 2.558983e-002
8073, -9.543345e-002, 2.952451e-002, 2.558983e-002
8074, -9.525528e-002, 2.853823e-002, 2.558983e-002
8075, -9.507710e-002, 2.755195e-002, 2.558983e-002
8076, -9.489893e-002, 2.656566e-002, 2.558983e-002
8077, -9.472076e-002, 2.557938e-002, 2.558983e-002
8078, -9.454259e-002, 2.459309e-002, 2.558983e-002
8079, -9.436441e-002, 2.360678e-002, 2.558983e-002
8080, -9.418622e-002, 2.262031e-002, 2.558987e-002
8081, -9.400802e-002, 2.163342e-002, 2.559005e-002
8082, -9.382987e-002, 2.064590e-002, 2.559061e-002
8083, -9.365182e-002, 1.965773e-002, 2.559164e-002
8084, -9.347374e-002, 1.866905e-002, 2.559283e-002
8085, -9.283220e-002, 1.776110e-002, 2.472297e-002
8086, -1.087934e-001, 1.625683e-001, 2.469813e-002
8087, -1.093881e-001, 1.624615e-001, 2.392676e-002
8088, -1.101024e-001, 1.623349e-001, 2.326113e-002
8089, -1.109176e-001, 1.621908e-001, 2.272135e-002
8090, -1.118101e-001, 1.620326e-001, 2.232432e-002
8091, -1.127550e-001, 1.618640e-001, 2.208158e-002
8092, -1.137264e-001, 1.616894e-001, 2.200000e-002
8093, -1.146977e-001, 1.615133e-001, 2.208191e-002
8094, -1.156424e-001, 1.613404e-001, 2.232517e-002
8095, -1.165347e-001, 1.611759e-001, 2.272320e-002
8096, -1.173505e-001, 1.610252e-001, 2.326517e-002
8097, -1.180675e-001, 1.608936e-001, 2.393631e-002
8098, -1.186664e-001, 1.607847e-001, 2.471831e-002
8099, -1.054468e-001, 1.438213e-001, 2.463918e-002
8100, -1.056249e-001, 1.448076e-001, 2.463918e-002
8101, -1.077621e-001, 1.566450e-001, 2.464110e-002
8102, -1.079375e-001, 1.576355e-001, 2.464617e-002
8103, -1.047341e-001, 1.398762e-001, 2.463918e-002
8104, -1.049123e-001, 1.408625e-001, 2.463918e-002
8105, -8.445461e-002, 2.028488e-002, 2.325081e-002
8106, -8.374271e-002, 2.041750e-002, 2.391100e-002
8107, -1.052686e-001, 1.428350e-001, 2.463918e-002
8108, -1.068722e-001, 1.517116e-001, 2.463918e-002
8109, -1.070503e-001, 1.526979e-001, 2.463918e-002
8110, -8.904141e-002, 1.945202e-002, 2.208308e-002
8111, -8.807052e-002, 1.962720e-002, 2.200001e-002
8112, -9.169440e-002, 1.897929e-002, 2.326868e-002
8113, -9.087847e-002, 1.912339e-002, 2.272617e-002
8114, -1.059813e-001, 1.467802e-001, 2.463918e-002
8115, -1.061595e-001, 1.477664e-001, 2.463918e-002
8116, -8.314626e-002, 2.052968e-002, 2.468006e-002
8117, -1.084500e-001, 1.605983e-001, 2.467957e-002
8118, -1.086210e-001, 1.615827e-001, 2.468975e-002
8119, -1.058031e-001, 1.457939e-001, 2.463918e-002
8120, -9.301015e-002, 1.875017e-002, 2.472187e-002
8121, -1.063376e-001, 1.487527e-001, 2.463918e-002
8122, -1.065158e-001, 1.497390e-001, 2.463918e-002
8123, -1.066940e-001, 1.507253e-001, 2.463918e-002
8124, -9.241158e-002, 1.885441e-002, 2.394002e-002
8125, -8.526745e-002, 2.013589e-002, 2.271491e-002
8126, -8.998609e-002, 1.928270e-002, 2.232736e-002
8127, -1.075845e-001, 1.556574e-001, 2.463983e-002
8128, -1.043777e-001, 1.379036e-001, 2.463918e-002
8129, -1.045559e-001, 1.388899e-001, 2.463918e-002
8130, -1.041996e-001, 1.369173e-001, 2.463918e-002
8131, -1.036650e-001, 1.339585e-001, 2.463918e-002
8132, -1.038432e-001, 1.349448e-001, 2.463918e-002
8133, -1.034869e-001, 1.329722e-001, 2.463918e-002
8134, -1.033087e-001, 1.319859e-001, 2.463918e-002
8135, -1.031305e-001, 1.309996e-001, 2.463918e-002
8136, -1.029524e-001, 1.300133e-001, 2.463918e-002
8137, -1.027742e-001, 1.290270e-001, 2.463918e-002
8138, -1.025960e-001, 1.280408e-001, 2.463918e-002
8139, -1.024178e-001, 1.270545e-001, 2.463918e-002
8140, -1.022397e-001, 1.260682e-001, 2.463918e-002
8141, -1.020615e-001, 1.250819e-001, 2.463918e-002
8142, -1.018833e-001, 1.240956e-001, 2.463918e-002
8143, -1.017051e-001, 1.231093e-001, 2.463918e-002
8144, -1.015270e-001, 1.221231e-001, 2.463918e-002
8145, -1.013488e-001, 1.211368e-001, 2.463918e-002
8146, -1.011706e-001, 1.201505e-001, 2.463918e-002
8147, -1.009925e-001, 1.191642e-001, 2.463918e-002
8148, -1.008143e-001, 1.181779e-001, 2.463918e-002
8149, -1.006361e-001, 1.171916e-001, 2.463918e-002
8150, -1.004579e-001, 1.162054e-001, 2.463918e-002
8151, -1.002798e-001, 1.152191e-001, 2.463918e-002
8152, -1.001016e-001, 1.142328e-001, 2.463918e-002
8153, -9.992342e-002, 1.132465e-001, 2.463918e-002
8154, -9.974525e-002, 1.122602e-001, 2.463918e-002
8155, -9.956708e-002, 1.112739e-001, 2.463918e-002
8156, -9.938891e-002, 1.102876e-001, 2.463918e-002
8157, -9.921073e-002, 1.093014e-001, 2.463918e-002
8158, -9.903256e-002, 1.083151e-001, 2.463918e-002
8159, -9.885439e-002, 1.073288e-001, 2.463918e-002
8160, -9.867622e-002, 1.063425e-001, 2.463918e-002
8161, -9.849804e-002, 1.053562e-001, 2.463918e-002
8162, -9.831987e-002, 1.043699e-001, 2.463918e-002
8163, -9.814170e-002, 1.033837e-001, 2.463918e-002
8164, -9.796353e-002, 1.023974e-001, 2.463918e-002
8165, -9.778535e-002, 1.014111e-001, 2.463918e-002
8166, -9.760718e-002, 1.004248e-001, 2.463918e-002
8167, -9.742901e-002, 9.943852e-002, 2.463918e-002
8168, -9.725083e-002, 9.845224e-002, 2.463918e-002
8169, -9.707266e-002, 9.746595e-002, 2.463918e-002
8170, -9.689449e-002, 9.647967e-002, 2.463918e-002
8171, -9.671632e-002, 9.549338e-002, 2.463918e-002
8172, -9.653814e-002, 9.450710e-002, 2.463918e-002
8173, -9.635997e-002, 9.352082e-002, 2.463918e-002
8174, -9.618180e-002, 9.253453e-002, 2.463918e-002
8175, -9.600363e-002, 9.154825e-002, 2.463918e-002
8176, -9.582545e-002, 9.056196e-002, 2.463918e-002
8177, -9.564728e-002, 8.957568e-002, 2.463918e-002
8178, -9.546911e-002, 8.858940e-002, 2.463918e-002
8179, -9.529094e-002, 8.760311e-002, 2.463918e-002
8180, -9.511276e-002, 8.661683e-002, 2.463918e-002
8181, -9.493459e-002, 8.563054e-002, 2.463918e-002
8182, -9.475642e-002, 8.464426e-002, 2.463918e-002
8183, -9.457825e-002, 8.365797e-002, 2.463918e-002
8184, -9.440007e-002, 8.267169e-002, 2.463918e-002
8185, -9.422190e-002, 8.168541e-002, 2.463918e-002
8186, -9.404373e-002, 8.069912e-002, 2.463918e-002
8187, -9.386556e-002, 7.971284e-002, 2.463918e-002
8188, -9.368738e-002, 7.872655e-002, 2.463918e-002
8189, -9.350921e-002, 7.774027e-002, 2.463918e-002
8190, -9.333104e-002, 7.675399e-002, 2.463918e-002
8191, -9.315287e-002, 7.576770e-002, 2.463918e-002
8192, -9.297469e-002, 7.478142e-002, 2.463918e-002
8193, -9.279652e-002, 7.379513e-002, 2.463918e-002
8194, -9.261835e-002, 7.280885e-002, 2.463918e-002
8195, -9.244018e-002, 7.182256e-002, 2.463918e-002
8196, -9.226200e-002, 7.083628e-002, 2.463918e-002
8197, -9.208383e-002, 6.985000e-002, 2.463918e-002
8198, -9.190566e-002, 6.886371e-002, 2.463918e-002
8199, -9.172749e-002, 6.787743e-002, 2.463918e-002
8200, -9.154931e-002, 6.689114e-002, 2.463918e-002
8201, -9.137114e-002, 6.590486e-002, 2.463918e-002
8202, -9.119297e-002, 6.491858e-002, 2.463918e-002
8203, -9.101479e-002, 6.393229e-002, 2.463918e-002
8204, -9.083662e-002, 6.294601e-002, 2.463918e-002
8205, -9.065845e-002, 6.195972e-002, 2.463918e-002
8206, -9.048028e-002, 6.097344e-002, 2.463918e-002
8207, -9.030210e-002, 5.998715e-002, 2.463918e-002
8208, -9.012393e-002, 5.900087e-002, 2.463918e-002
8209, -8.994576e-002, 5.801459e-002, 2.463918e-002
8210, -8.976759e-002, 5.702830e-002, 2.463918e-002
8211, -8.958941e-002, 5.604202e-002, 2.463918e-002
8212, -8.941124e-002, 5.505573e-002, 2.463918e-002
8213, -8.923307e-002, 5.406945e-002, 2.463918e-002
8214, -8.905490e-002, 5.308317e-002, 2.463918e-002
8215, -8.887672e-002, 5.209688e-002, 2.463918e-002
8216, -8.869855e-002, 5.111060e-002, 2.463918e-002
8217, -8.852038e-002, 5.012431e-002, 2.463918e-002
8218, -8.834221e-002, 4.913803e-002, 2.463918e-002
8219, -8.816403e-002, 4.815175e-002, 2.463918e-002
8220, -8.798586e-002, 4.716546e-002, 2.463918e-002
8221, -8.780769e-002, 4.617918e-002, 2.463918e-002
8222, -8.762952e-002, 4.519289e-002, 2.463918e-002
8223, -8.745134e-002, 4.420661e-002, 2.463918e-002
8224, -8.727317e-002, 4.322032e-002, 2.463918e-002
8225, -8.709500e-002, 4.223404e-002, 2.463918e-002
8226, -8.691683e-002, 4.124776e-002, 2.463918e-002
8227, -8.673865e-002, 4.026147e-002, 2.463918e-002
8228, -8.656048e-002, 3.927519e-002, 2.463918e-002
8229, -8.638231e-002, 3.828890e-002, 2.463918e-002
8230, -8.620414e-002, 3.730262e-002, 2.463918e-002
8231, -8.602596e-002, 3.631634e-002, 2.463918e-002
8232, -8.584779e-002, 3.533005e-002, 2.463918e-002
8233, -8.566962e-002, 3.434377e-002, 2.463918e-002
8234, -8.549145e-002, 3.335748e-002, 2.463918e-002
8235, -8.531327e-002, 3.237120e-002, 2.463918e-002
8236, -8.513510e-002, 3.138491e-002, 2.463918e-002
8237, -8.495693e-002, 3.039863e-002, 2.463918e-002
8238, -8.477876e-002, 2.941235e-002, 2.463918e-002
8239, -8.460058e-002, 2.842606e-002, 2.463918e-002
8240, -8.442241e-002, 2.743978e-002, 2.463918e-002
8241, -8.424418e-002, 2.645347e-002, 2.463926e-002
8242, -8.406562e-002, 2.546706e-002, 2.463979e-002
8243, -8.388593e-002, 2.448035e-002, 2.464189e-002
8244, -8.370370e-002, 2.349301e-002, 2.464753e-002
8245, -8.351841e-002, 2.250506e-002, 2.465750e-002
8246, -8.333187e-002, 2.151711e-002, 2.466937e-002
8247, -1.082798e-001, 1.596144e-001, 2.466845e-002
8248, -1.050904e-001, 1.418487e-001, 2.463918e-002
8249, -1.081096e-001, 1.586269e-001, 2.465648e-002
8250, -8.710059e-002, 1.980273e-002, 2.208011e-002
8251, -8.615826e-002, 1.997392e-002, 2.232058e-002
8252, -1.072285e-001, 1.536842e-001, 2.463919e-002
8253, -1.074066e-001, 1.546706e-001, 2.463935e-002
8254, -1.040214e-001, 1.359310e-001, 2.463918e-002
8255, -1.184883e-001, 1.597987e-001, 2.471831e-002
8256, -1.183102e-001, 1.588130e-001, 2.471830e-002
8257, -1.181321e-001, 1.578272e-001, 2.471830e-002
8258, -1.179538e-001, 1.568405e-001, 2.471830e-002
8259, -1.177756e-001, 1.558536e-001, 2.471830e-002
8260, -1.175973e-001, 1.548668e-001, 2.471831e-002
8261, -1.174191e-001, 1.538803e-001, 2.471831e-002
8262, -1.172409e-001, 1.528939e-001, 2.471831e-002
8263, -1.170627e-001, 1.519076e-001, 2.471832e-002
8264, -1.168846e-001, 1.509213e-001, 2.471832e-002
8265, -1.167064e-001, 1.499350e-001, 2.471833e-002
8266, -1.165282e-001, 1.489487e-001, 2.471833e-002
8267, -1.163500e-001, 1.479625e-001, 2.471833e-002
8268, -1.161719e-001, 1.469762e-001, 2.471833e-002
8269, -1.159937e-001, 1.459899e-001, 2.471833e-002
8270, -1.158155e-001, 1.450036e-001, 2.471833e-002
8271, -1.156374e-001, 1.440173e-001, 2.471833e-002
8272, -1.154592e-001, 1.430310e-001, 2.471833e-002
8273, -1.152810e-001, 1.420447e-001, 2.471833e-002
8274, -1.151028e-001, 1.410585e-001, 2.471833e-002
8275, -1.149247e-001, 1.400722e-001, 2.471833e-002
8276, -1.147465e-001, 1.390859e-001, 2.471833e-002
8277, -1.145683e-001, 1.380996e-001, 2.471833e-002
8278, -1.143901e-001, 1.371133e-001, 2.471833e-002
8279, -1.142120e-001, 1.361270e-001, 2.471833e-002
8280, -1.140338e-001, 1.351408e-001, 2.471833e-002
8281, -1.138556e-001, 1.341545e-001, 2.471833e-002
8282, -1.136775e-001, 1.331682e-001, 2.471833e-002
8283, -1.134993e-001, 1.321819e-001, 2.471833e-002
8284, -1.133211e-001, 1.311956e-001, 2.471833e-002
8285, -1.131429e-001, 1.302093e-001, 2.471833e-002
8286, -1.129648e-001, 1.292231e-001, 2.471833e-002
8287, -1.127866e-001, 1.282368e-001, 2.471833e-002
8288, -1.126084e-001, 1.272505e-001, 2.471833e-002
8289, -1.124302e-001, 1.262642e-001, 2.471833e-002
8290, -1.122521e-001, 1.252779e-001, 2.471833e-002
8291, -1.120739e-001, 1.242916e-001, 2.471833e-002
8292, -1.118957e-001, 1.233054e-001, 2.471833e-002
8293, -1.117176e-001, 1.223191e-001, 2.471833e-002
8294, -1.115394e-001, 1.213328e-001, 2.471833e-002
8295, -1.113612e-001, 1.203465e-001, 2.471833e-002
8296, -1.111830e-001, 1.193602e-001, 2.471833e-002
8297, -1.110049e-001, 1.183739e-001, 2.471833e-002
8298, -1.108267e-001, 1.173876e-001, 2.471833e-002
8299, -1.106485e-001, 1.164014e-001, 2.471833e-002
8300, -1.104703e-001, 1.154151e-001, 2.471833e-002
8301, -1.102922e-001, 1.144288e-001, 2.471833e-002
8302, -1.101140e-001, 1.134425e-001, 2.471833e-002
8303, -1.099358e-001, 1.124562e-001, 2.471833e-002
8304, -1.097577e-001, 1.114699e-001, 2.471833e-002
8305, -1.095795e-001, 1.104837e-001, 2.471833e-002
8306, -1.094013e-001, 1.094974e-001, 2.471833e-002
8307, -1.092231e-001, 1.085111e-001, 2.471833e-002
8308, -1.090450e-001, 1.075248e-001, 2.471833e-002
8309, -1.088668e-001, 1.065385e-001, 2.471833e-002
8310, -1.086886e-001, 1.055522e-001, 2.471833e-002
8311, -1.085104e-001, 1.045660e-001, 2.471833e-002
8312, -1.083323e-001, 1.035797e-001, 2.471833e-002
8313, -1.081541e-001, 1.025934e-001, 2.471833e-002
8314, -1.079759e-001, 1.016071e-001, 2.471833e-002
8315, -1.077978e-001, 1.006208e-001, 2.471833e-002
8316, -1.076196e-001, 9.963453e-002, 2.471833e-002
8317, -1.074414e-001, 9.864825e-002, 2.471833e-002
8318, -1.072632e-001, 9.766196e-002, 2.471833e-002
8319, -1.070851e-001, 9.667568e-002, 2.471833e-002
8320, -1.069069e-001, 9.568939e-002, 2.471833e-002
8321, -1.067287e-001, 9.470311e-002, 2.471833e-002
8322, -1.065505e-001, 9.371683e-002, 2.471833e-002
8323, -1.063724e-001, 9.273054e-002, 2.471833e-002
8324, -1.061942e-001, 9.174426e-002, 2.471833e-002
8325, -1.060160e-001, 9.075797e-002, 2.471833e-002
8326, -1.058379e-001, 8.977169e-002, 2.471833e-002
8327, -1.056597e-001, 8.878541e-002, 2.471833e-002
8328, -1.054815e-001, 8.779912e-002, 2.471833e-002
8329, -1.053033e-001, 8.681284e-002, 2.471833e-002
8330, -1.051252e-001, 8.582655e-002, 2.471833e-002
8331, -1.049470e-001, 8.484027e-002, 2.471833e-002
8332, -1.047688e-001, 8.385399e-002, 2.471833e-002
8333, -1.045907e-001, 8.286770e-002, 2.471833e-002
8334, -1.044125e-001, 8.188142e-002, 2.471833e-002
8335, -1.042343e-001, 8.089513e-002, 2.471833e-002
8336, -1.040561e-001, 7.990885e-002, 2.471833e-002
8337, -1.038780e-001, 7.892256e-002, 2.471833e-002
8338, -1.036998e-001, 7.793628e-002, 2.471833e-002
8339, -1.035216e-001, 7.695000e-002, 2.471833e-002
8340, -1.033434e-001, 7.596371e-002, 2.471833e-002
8341, -1.031653e-001, 7.497743e-002, 2.471833e-002
8342, -1.029871e-001, 7.399114e-002, 2.471833e-002
8343, -1.028089e-001, 7.300486e-002, 2.471833e-002
8344, -1.026308e-001, 7.201858e-002, 2.471833e-002
8345, -1.024526e-001, 7.103229e-002, 2.471833e-002
8346, -1.022744e-001, 7.004601e-002, 2.471833e-002
8347, -1.020962e-001, 6.905972e-002, 2.471833e-002
8348, -1.019181e-001, 6.807344e-002, 2.471833e-002
8349, -1.017399e-001, 6.708715e-002, 2.471833e-002
8350, -1.015617e-001, 6.610087e-002, 2.471833e-002
8351, -1.013835e-001, 6.511459e-002, 2.471833e-002
8352, -1.012054e-001, 6.412830e-002, 2.471833e-002
8353, -1.010272e-001, 6.314202e-002, 2.471833e-002
8354, -1.008490e-001, 6.215573e-002, 2.471833e-002
8355, -1.006709e-001, 6.116945e-002, 2.471833e-002
8356, -1.004927e-001, 6.018317e-002, 2.471833e-002
8357, -1.003145e-001, 5.919688e-002, 2.471833e-002
8358, -1.001363e-001, 5.821060e-002, 2.471833e-002
8359, -9.995816e-002, 5.722431e-002, 2.471833e-002
8360, -9.977999e-002, 5.623803e-002, 2.471833e-002
8361, -9.960182e-002, 5.525174e-002, 2.471833e-002
8362, -9.942365e-002, 5.426546e-002, 2.471833e-002
8363, -9.924547e-002, 5.327918e-002, 2.471833e-002
8364, -9.906730e-002, 5.229289e-002, 2.471833e-002
8365, -9.888913e-002, 5.130661e-002, 2.471833e-002
8366, -9.871096e-002, 5.032032e-002, 2.471833e-002
8367, -9.853278e-002, 4.933404e-002, 2.471833e-002
8368, -9.835461e-002, 4.834776e-002, 2.471833e-002
8369, -9.817644e-002, 4.736147e-002, 2.471833e-002
8370, -9.799827e-002, 4.637519e-002, 2.471833e-002
8371, -9.782009e-002, 4.538890e-002, 2.471833e-002
8372, -9.764192e-002, 4.440262e-002, 2.471833e-002
8373, -9.746375e-002, 4.341633e-002, 2.471833e-002
8374, -9.728558e-002, 4.243005e-002, 2.471833e-002
8375, -9.710740e-002, 4.144377e-002, 2.471833e-002
8376, -9.692923e-002, 4.045748e-002, 2.471833e-002
8377, -9.675106e-002, 3.947120e-002, 2.471833e-002
8378, -9.657289e-002, 3.848491e-002, 2.471833e-002
8379, -9.639471e-002, 3.749863e-002, 2.471833e-002
8380, -9.621654e-002, 3.651235e-002, 2.471833e-002
8381, -9.603837e-002, 3.552606e-002, 2.471833e-002
8382, -9.586020e-002, 3.453978e-002, 2.471833e-002
8383, -9.568202e-002, 3.355349e-002, 2.471833e-002
8384, -9.550385e-002, 3.256721e-002, 2.471833e-002
8385, -9.532568e-002, 3.158093e-002, 2.471833e-002
8386, -9.514751e-002, 3.059464e-002, 2.471833e-002
8387, -9.496933e-002, 2.960836e-002, 2.471833e-002
8388, -9.479116e-002, 2.862207e-002, 2.471833e-002
8389, -9.461299e-002, 2.763579e-002, 2.471833e-002
8390, -9.443481e-002, 2.664950e-002, 2.471833e-002
8391, -9.425664e-002, 2.566322e-002, 2.471833e-002
8392, -9.407846e-002, 2.467692e-002, 2.471833e-002
8393, -9.390027e-002, 2.369047e-002, 2.471833e-002
8394, -9.372201e-002, 2.270358e-002, 2.471837e-002
8395, -9.354372e-002, 2.171593e-002, 2.471856e-002
8396, -9.336560e-002, 2.072761e-002, 2.471920e-002
8397, -9.318781e-002, 1.973888e-002, 2.472043e-002
8398, -1.092158e-001, 1.614783e-001, 2.392112e-002
8399, -1.099302e-001, 1.613554e-001, 2.325751e-002
8400, -1.107453e-001, 1.612140e-001, 2.271910e-002
8401, -1.116372e-001, 1.610566e-001, 2.232316e-002
8402, -1.125812e-001, 1.608880e-001, 2.208117e-002
8403, -1.135517e-001, 1.607129e-001, 2.200000e-002
8404, -1.145221e-001, 1.605359e-001, 2.208207e-002
8405, -1.154660e-001, 1.603616e-001, 2.232531e-002
8406, -1.163577e-001, 1.601952e-001, 2.272327e-002
8407, -1.171729e-001, 1.600424e-001, 2.326519e-002
8408, -1.178896e-001, 1.599087e-001, 2.393631e-002
8409, -1.083769e-001, 1.565370e-001, 2.386479e-002
8410, -1.085496e-001, 1.575322e-001, 2.387219e-002
8411, -8.545444e-002, 2.112158e-002, 2.271020e-002
8412, -8.464399e-002, 2.127142e-002, 2.324235e-002
8413, -1.039251e-001, 1.318745e-001, 2.386119e-002
8414, -1.041033e-001, 1.328608e-001, 2.386120e-002
8415, -8.921940e-002, 2.043766e-002, 2.208307e-002
8416, -8.825026e-002, 2.061257e-002, 2.200001e-002
8417, -9.016353e-002, 2.026896e-002, 2.232711e-002
8418, -1.058850e-001, 1.427237e-001, 2.386119e-002
8419, -1.060632e-001, 1.437099e-001, 2.386120e-002
8420, -1.074886e-001, 1.516002e-001, 2.386120e-002
8421, -1.076667e-001, 1.525865e-001, 2.386121e-002
8422, -9.105561e-002, 2.011082e-002, 2.272551e-002
8423, -1.090469e-001, 1.604983e-001, 2.391258e-002
8424, -1.067759e-001, 1.476551e-001, 2.386119e-002
8425, -1.069541e-001, 1.486414e-001, 2.386120e-002
8426, -1.071322e-001, 1.496277e-001, 2.386119e-002
8427, -1.073104e-001, 1.506139e-001, 2.386120e-002
8428, -9.258875e-002, 1.984307e-002, 2.393849e-002
8429, -1.044597e-001, 1.348334e-001, 2.386119e-002
8430, -1.046378e-001, 1.358197e-001, 2.386120e-002
8431, -8.393105e-002, 2.140460e-002, 2.390043e-002
8432, -1.037470e-001, 1.308883e-001, 2.386120e-002
8433, -1.087168e-001, 1.585279e-001, 2.388540e-002
8434, -1.049942e-001, 1.377922e-001, 2.386120e-002
8435, -1.051723e-001, 1.387785e-001, 2.386120e-002
8436, -1.048160e-001, 1.368060e-001, 2.386120e-002
8437, -1.042815e-001, 1.338471e-001, 2.386119e-002
8438, -1.035688e-001, 1.299020e-001, 2.386120e-002
8439, -1.033906e-001, 1.289157e-001, 2.386119e-002
8440, -1.032124e-001, 1.279294e-001, 2.386120e-002
8441, -1.030343e-001, 1.269431e-001, 2.386119e-002
8442, -1.028561e-001, 1.259568e-001, 2.386119e-002
8443, -1.026779e-001, 1.249705e-001, 2.386119e-002
8444, -1.024997e-001, 1.239843e-001, 2.386120e-002
8445, -1.023216e-001, 1.229980e-001, 2.386120e-002
8446, -1.021434e-001, 1.220117e-001, 2.386120e-002
8447, -1.019652e-001, 1.210254e-001, 2.386119e-002
8448, -1.017871e-001, 1.200391e-001, 2.386119e-002
8449, -1.016089e-001, 1.190528e-001, 2.386120e-002
8450, -1.014307e-001, 1.180666e-001, 2.386120e-002
8451, -1.012525e-001, 1.170803e-001, 2.386120e-002
8452, -1.010744e-001, 1.160940e-001, 2.386120e-002
8453, -1.008962e-001, 1.151077e-001, 2.386120e-002
8454, -1.007180e-001, 1.141214e-001, 2.386120e-002
8455, -1.005399e-001, 1.131351e-001, 2.386120e-002
8456, -1.003617e-001, 1.121489e-001, 2.386120e-002
8457, -1.001835e-001, 1.111626e-001, 2.386120e-002
8458, -1.000053e-001, 1.101763e-001, 2.386120e-002
8459, -9.982716e-002, 1.091900e-001, 2.386120e-002
8460, -9.964899e-002, 1.082037e-001, 2.386120e-002
8461, -9.947081e-002, 1.072174e-001, 2.386120e-002
8462, -9.929264e-002, 1.062312e-001, 2.386120e-002
8463, -9.911447e-002, 1.052449e-001, 2.386120e-002
8464, -9.893630e-002, 1.042586e-001, 2.386120e-002
8465, -9.875812e-002, 1.032723e-001, 2.386120e-002
8466, -9.857995e-002, 1.022860e-001, 2.386120e-002
8467, -9.840178e-002, 1.012997e-001, 2.386120e-002
8468, -9.822361e-002, 1.003134e-001, 2.386120e-002
8469, -9.804543e-002, 9.932716e-002, 2.386120e-002
8470, -9.786726e-002, 9.834088e-002, 2.386120e-002
8471, -9.768909e-002, 9.735459e-002, 2.386120e-002
8472, -9.751092e-002, 9.636831e-002, 2.386120e-002
8473, -9.733274e-002, 9.538203e-002, 2.386120e-002
8474, -9.715457e-002, 9.439574e-002, 2.386120e-002
8475, -9.697640e-002, 9.340946e-002, 2.386120e-002
8476, -9.679823e-002, 9.242317e-002, 2.386120e-002
8477, -9.662005e-002, 9.143689e-002, 2.386120e-002
8478, -9.644188e-002, 9.045061e-002, 2.386120e-002
8479, -9.626371e-002, 8.946432e-002, 2.386120e-002
8480, -9.608554e-002, 8.847804e-002, 2.386120e-002
8481, -9.590736e-002, 8.749175e-002, 2.386120e-002
8482, -9.572919e-002, 8.650547e-002, 2.386120e-002
8483, -9.555102e-002, 8.551918e-002, 2.386120e-002
8484, -9.537285e-002, 8.453290e-002, 2.386120e-002
8485, -9.519467e-002, 8.354662e-002, 2.386120e-002
8486, -9.501650e-002, 8.256033e-002, 2.386120e-002
8487, -9.483833e-002, 8.157405e-002, 2.386120e-002
8488, -9.466016e-002, 8.058776e-002, 2.386120e-002
8489, -9.448198e-002, 7.960148e-002, 2.386120e-002
8490, -9.430381e-002, 7.861520e-002, 2.386120e-002
8491, -9.412564e-002, 7.762891e-002, 2.386120e-002
8492, -9.394746e-002, 7.664263e-002, 2.386120e-002
8493, -9.376929e-002, 7.565634e-002, 2.386120e-002
8494, -9.359112e-002, 7.467006e-002, 2.386120e-002
8495, -9.341295e-002, 7.368378e-002, 2.386120e-002
8496, -9.323477e-002, 7.269749e-002, 2.386120e-002
8497, -9.305660e-002, 7.171121e-002, 2.386120e-002
8498, -9.287843e-002, 7.072492e-002, 2.386120e-002
8499, -9.270026e-002, 6.973864e-002, 2.386120e-002
8500, -9.252208e-002, 6.875235e-002, 2.386120e-002
8501, -9.234391e-002, 6.776607e-002, 2.386120e-002
8502, -9.216574e-002, 6.677979e-002, 2.386120e-002
8503, -9.198757e-002, 6.579350e-002, 2.386120e-002
8504, -9.180939e-002, 6.480722e-002, 2.386120e-002
8505, -9.163122e-002, 6.382093e-002, 2.386120e-002
8506, -9.145305e-002, 6.283465e-002, 2.386120e-002
8507, -9.127488e-002, 6.184837e-002, 2.386120e-002
8508, -9.109670e-002, 6.086208e-002, 2.386120e-002
8509, -9.091853e-002, 5.987580e-002, 2.386120e-002
8510, -9.074036e-002, 5.888951e-002, 2.386120e-002
8511, -9.056219e-002, 5.790323e-002, 2.386120e-002
8512, -9.038401e-002, 5.691694e-002, 2.386120e-002
8513, -9.020584e-002, 5.593066e-002, 2.386120e-002
8514, -9.002767e-002, 5.494438e-002, 2.386120e-002
8515, -8.984950e-002, 5.395809e-002, 2.386120e-002
8516, -8.967132e-002, 5.297181e-002, 2.386120e-002
8517, -8.949315e-002, 5.198552e-002, 2.386120e-002
8518, -8.931498e-002, 5.099924e-002, 2.386120e-002
8519, -8.913681e-002, 5.001296e-002, 2.386120e-002
8520, -8.895863e-002, 4.902667e-002, 2.386120e-002
8521, -8.878046e-002, 4.804039e-002, 2.386120e-002
8522, -8.860229e-002, 4.705410e-002, 2.386120e-002
8523, -8.842412e-002, 4.606782e-002, 2.386120e-002
8524, -8.824594e-002, 4.508153e-002, 2.386120e-002
8525, -8.806777e-002, 4.409525e-002, 2.386120e-002
8526, -8.788960e-002, 4.310897e-002, 2.386120e-002
8527, -8.771142e-002, 4.212268e-002, 2.386120e-002
8528, -8.753325e-002, 4.113640e-002, 2.386120e-002
8529, -8.735508e-002, 4.015011e-002, 2.386120e-002
8530, -8.717691e-002, 3.916383e-002, 2.386120e-002
8531, -8.699873e-002, 3.817755e-002, 2.386120e-002
8532, -8.682056e-002, 3.719126e-002, 2.386120e-002
8533, -8.664239e-002, 3.620498e-002, 2.386120e-002
8534, -8.646422e-002, 3.521869e-002, 2.386120e-002
8535, -8.628604e-002, 3.423241e-002, 2.386120e-002
8536, -8.610787e-002, 3.324612e-002, 2.386120e-002
8537, -8.592970e-002, 3.225984e-002, 2.386120e-002
8538, -8.575153e-002, 3.127356e-002, 2.386120e-002
8539, -8.557335e-002, 3.028727e-002, 2.386120e-002
8540, -8.539518e-002, 2.930099e-002, 2.386120e-002
8541, -8.521701e-002, 2.831470e-002, 2.386120e-002
8542, -8.503872e-002, 2.732839e-002, 2.386131e-002
8543, -8.485996e-002, 2.634199e-002, 2.386190e-002
8544, -8.468003e-002, 2.535535e-002, 2.386364e-002
8545, -8.449771e-002, 2.436828e-002, 2.386779e-002
8546, -8.431136e-002, 2.338055e-002, 2.387601e-002
8547, -8.412128e-002, 2.239241e-002, 2.388808e-002
8548, -1.088812e-001, 1.595166e-001, 2.390021e-002
8549, -1.057069e-001, 1.417374e-001, 2.386119e-002
8550, -1.062414e-001, 1.446962e-001, 2.386120e-002
8551, -8.728294e-002, 2.078803e-002, 2.207941e-002
8552, -8.634337e-002, 2.095938e-002, 2.231820e-002
8553, -1.078449e-001, 1.535728e-001, 2.386125e-002
8554, -1.080228e-001, 1.545594e-001, 2.386156e-002
8555, -1.082001e-001, 1.555473e-001, 2.386273e-002
8556, -9.187141e-002, 1.996766e-002, 2.326750e-002
8557, -1.064195e-001, 1.456825e-001, 2.386120e-002
8558, -1.177118e-001, 1.589243e-001, 2.393631e-002
8559, -1.175338e-001, 1.579390e-001, 2.393630e-002
8560, -1.173554e-001, 1.569517e-001, 2.393631e-002
8561, -1.171769e-001, 1.559635e-001, 2.393631e-002
8562, -1.169985e-001, 1.549759e-001, 2.393632e-002
8563, -1.168202e-001, 1.539889e-001, 2.393632e-002
8564, -1.166420e-001, 1.530023e-001, 2.393636e-002
8565, -1.164639e-001, 1.520158e-001, 2.393643e-002
8566, -1.162858e-001, 1.510295e-001, 2.393650e-002
8567, -1.161076e-001, 1.500432e-001, 2.393654e-002
8568, -1.159295e-001, 1.490569e-001, 2.393657e-002
8569, -1.157513e-001, 1.480706e-001, 2.393658e-002
8570, -1.155731e-001, 1.470843e-001, 2.393658e-002
8571, -1.153950e-001, 1.460980e-001, 2.393658e-002
8572, -1.152168e-001, 1.451118e-001, 2.393658e-002
8573, -1.150386e-001, 1.441255e-001, 2.393658e-002
8574, -1.148604e-001, 1.431392e-001, 2.393658e-002
8575, -1.146823e-001, 1.421529e-001, 2.393658e-002
8576, -1.145041e-001, 1.411666e-001, 2.393658e-002
8577, -1.143259e-001, 1.401803e-001, 2.393658e-002
8578, -1.141478e-001, 1.391941e-001, 2.393658e-002
8579, -1.139696e-001, 1.382078e-001, 2.393658e-002
8580, -1.137914e-001, 1.372215e-001, 2.393658e-002
8581, -1.136132e-001, 1.362352e-001, 2.393658e-002
8582, -1.134351e-001, 1.352489e-001, 2.393658e-002
8583, -1.132569e-001, 1.342626e-001, 2.393658e-002
8584, -1.130787e-001, 1.332764e-001, 2.393658e-002
8585, -1.129006e-001, 1.322901e-001, 2.393658e-002
8586, -1.127224e-001, 1.313038e-001, 2.393658e-002
8587, -1.125442e-001, 1.303175e-001, 2.393658e-002
8588, -1.123660e-001, 1.293312e-001, 2.393658e-002
8589, -1.121879e-001, 1.283449e-001, 2.393658e-002
8590, -1.120097e-001, 1.273586e-001, 2.393658e-002
8591, -1.118315e-001, 1.263724e-001, 2.393658e-002
8592, -1.116533e-001, 1.253861e-001, 2.393658e-002
8593, -1.114752e-001, 1.243998e-001, 2.393658e-002
8594, -1.112970e-001, 1.234135e-001, 2.393658e-002
8595, -1.111188e-001, 1.224272e-001, 2.393658e-002
8596, -1.109407e-001, 1.214409e-001, 2.393658e-002
8597, -1.107625e-001, 1.204547e-001, 2.393658e-002
8598, -1.105843e-001, 1.194684e-001, 2.393658e-002
8599, -1.104061e-001, 1.184821e-001, 2.393658e-002
8600, -1.102280e-001, 1.174958e-001, 2.393658e-002
8601, -1.100498e-001, 1.165095e-001, 2.393658e-002
8602, -1.098716e-001, 1.155232e-001, 2.393658e-002
8603, -1.096934e-001, 1.145370e-001, 2.393658e-002
8604, -1.095153e-001, 1.135507e-001, 2.393658e-002
8605, -1.093371e-001, 1.125644e-001, 2.393658e-002
8606, -1.091589e-001, 1.115781e-001, 2.393658e-002
8607, -1.089808e-001, 1.105918e-001, 2.393658e-002
8608, -1.088026e-001, 1.096055e-001, 2.393658e-002
8609, -1.086244e-001, 1.086192e-001, 2.393658e-002
8610, -1.084462e-001, 1.076330e-001, 2.393658e-002
8611, -1.082681e-001, 1.066467e-001, 2.393658e-002
8612, -1.080899e-001, 1.056604e-001, 2.393658e-002
8613, -1.079117e-001, 1.046741e-001, 2.393658e-002
8614, -1.077335e-001, 1.036878e-001, 2.393658e-002
8615, -1.075554e-001, 1.027015e-001, 2.393658e-002
8616, -1.073772e-001, 1.017153e-001, 2.393658e-002
8617, -1.071990e-001, 1.007290e-001, 2.393658e-002
8618, -1.070209e-001, 9.974269e-002, 2.393658e-002
8619, -1.068427e-001, 9.875641e-002, 2.393658e-002
8620, -1.066645e-001, 9.777012e-002, 2.393658e-002
8621, -1.064863e-001, 9.678384e-002, 2.393658e-002
8622, -1.063082e-001, 9.579755e-002, 2.393658e-002
8623, -1.061300e-001, 9.481127e-002, 2.393658e-002
8624, -1.059518e-001, 9.382499e-002, 2.393658e-002
8625, -1.057736e-001, 9.283870e-002, 2.393658e-002
8626, -1.055955e-001, 9.185242e-002, 2.393658e-002
8627, -1.054173e-001, 9.086613e-002, 2.393658e-002
8628, -1.052391e-001, 8.987985e-002, 2.393658e-002
8629, -1.050610e-001, 8.889356e-002, 2.393658e-002
8630, -1.048828e-001, 8.790728e-002, 2.393658e-002
8631, -1.047046e-001, 8.692100e-002, 2.393658e-002
8632, -1.045264e-001, 8.593471e-002, 2.393658e-002
8633, -1.043483e-001, 8.494843e-002, 2.393658e-002
8634, -1.041701e-001, 8.396214e-002, 2.393658e-002
8635, -1.039919e-001, 8.297586e-002, 2.393658e-002
8636, -1.038137e-001, 8.198958e-002, 2.393658e-002
8637, -1.036356e-001, 8.100329e-002, 2.393658e-002
8638, -1.034574e-001, 8.001701e-002, 2.393658e-002
8639, -1.032792e-001, 7.903072e-002, 2.393658e-002
8640, -1.031011e-001, 7.804444e-002, 2.393658e-002
8641, -1.029229e-001, 7.705815e-002, 2.393658e-002
8642, -1.027447e-001, 7.607187e-002, 2.393658e-002
8643, -1.025665e-001, 7.508559e-002, 2.393658e-002
8644, -1.023884e-001, 7.409930e-002, 2.393658e-002
8645, -1.022102e-001, 7.311302e-002, 2.393658e-002
8646, -1.020320e-001, 7.212673e-002, 2.393658e-002
8647, -1.018539e-001, 7.114045e-002, 2.393658e-002
8648, -1.016757e-001, 7.015417e-002, 2.393658e-002
8649, -1.014975e-001, 6.916788e-002, 2.393658e-002
8650, -1.013193e-001, 6.818160e-002, 2.393658e-002
8651, -1.011412e-001, 6.719531e-002, 2.393658e-002
8652, -1.009630e-001, 6.620903e-002, 2.393658e-002
8653, -1.007848e-001, 6.522274e-002, 2.393658e-002
8654, -1.006066e-001, 6.423646e-002, 2.393658e-002
8655, -1.004285e-001, 6.325018e-002, 2.393658e-002
8656, -1.002503e-001, 6.226389e-002, 2.393658e-002
8657, -1.000721e-001, 6.127761e-002, 2.393658e-002
8658, -9.989395e-002, 6.029132e-002, 2.393658e-002
8659, -9.971578e-002, 5.930504e-002, 2.393658e-002
8660, -9.953761e-002, 5.831876e-002, 2.393658e-002
8661, -9.935943e-002, 5.733247e-002, 2.393658e-002
8662, -9.918126e-002, 5.634619e-002, 2.393658e-002
8663, -9.900309e-002, 5.535990e-002, 2.393658e-002
8664, -9.882492e-002, 5.437362e-002, 2.393658e-002
8665, -9.864674e-002, 5.338734e-002, 2.393658e-002
8666, -9.846857e-002, 5.240105e-002, 2.393658e-002
8667, -9.829040e-002, 5.141477e-002, 2.393658e-002
8668, -9.811223e-002, 5.042848e-002, 2.393658e-002
8669, -9.793405e-002, 4.944220e-002, 2.393658e-002
8670, -9.775588e-002, 4.845591e-002, 2.393658e-002
8671, -9.757771e-002, 4.746963e-002, 2.393658e-002
8672, -9.739954e-002, 4.648335e-002, 2.393658e-002
8673, -9.722136e-002, 4.549706e-002, 2.393658e-002
8674, -9.704319e-002, 4.451078e-002, 2.393658e-002
8675, -9.686502e-002, 4.352449e-002, 2.393658e-002
8676, -9.668685e-002, 4.253821e-002, 2.393658e-002
8677, -9.650867e-002, 4.155193e-002, 2.393658e-002
8678, -9.633050e-002, 4.056564e-002, 2.393658e-002
8679, -9.615233e-002, 3.957936e-002, 2.393658e-002
8680, -9.597416e-002, 3.859307e-002, 2.393658e-002
8681, -9.579598e-002, 3.760679e-002, 2.393658e-002
8682, -9.561781e-002, 3.662050e-002, 2.393658e-002
8683, -9.543964e-002, 3.563422e-002, 2.393658e-002
8684, -9.526147e-002, 3.464794e-002, 2.393658e-002
8685, -9.508329e-002, 3.366165e-002, 2.393658e-002
8686, -9.490512e-002, 3.267537e-002, 2.393658e-002
8687, -9.472695e-002, 3.168908e-002, 2.393658e-002
8688, -9.454877e-002, 3.070280e-002, 2.393658e-002
8689, -9.437060e-002, 2.971652e-002, 2.393658e-002
8690, -9.419243e-002, 2.873023e-002, 2.393658e-002
8691, -9.401426e-002, 2.774395e-002, 2.393658e-002
8692, -9.383609e-002, 2.675766e-002, 2.393658e-002
8693, -9.365789e-002, 2.577136e-002, 2.393656e-002
8694, -9.347964e-002, 2.478491e-002, 2.393651e-002
8695, -9.330134e-002, 2.379801e-002, 2.393649e-002
8696, -9.312294e-002, 2.281021e-002, 2.393654e-002
8697, -9.294445e-002, 2.182137e-002, 2.393669e-002
8698, -9.276627e-002, 2.083207e-002, 2.393727e-002
8699, -1.065977e-001, 1.466688e-001, 2.386120e-002
8700, -1.053505e-001, 1.397648e-001, 2.386120e-002
8701, -1.055287e-001, 1.407511e-001, 2.386120e-002
8702, -1.097626e-001, 1.603790e-001, 2.325081e-002
8703, -1.105773e-001, 1.602383e-001, 2.271473e-002
8704, -1.114677e-001, 1.600801e-001, 2.232085e-002
8705, -1.124098e-001, 1.599104e-001, 2.208033e-002
8706, -1.133783e-001, 1.597343e-001, 2.200000e-002
8707, -1.143470e-001, 1.595563e-001, 2.208238e-002
8708, -1.152897e-001, 1.593811e-001, 2.232560e-002
8709, -1.161807e-001, 1.592139e-001, 2.272343e-002
8710, -1.169955e-001, 1.590598e-001, 2.326524e-002
8711, -8.564606e-002, 2.210829e-002, 2.270318e-002
8712, -8.483642e-002, 2.225884e-002, 2.323176e-002
8713, -1.050161e-001, 1.337144e-001, 2.319807e-002
8714, -1.051942e-001, 1.347007e-001, 2.319813e-002
8715, -1.059069e-001, 1.386458e-001, 2.319819e-002
8716, -1.060850e-001, 1.396321e-001, 2.319825e-002
8717, -1.053723e-001, 1.356870e-001, 2.319820e-002
8718, -1.055505e-001, 1.366733e-001, 2.319817e-002
8719, -9.034141e-002, 2.125670e-002, 2.232692e-002
8720, -8.939914e-002, 2.142502e-002, 2.208330e-002
8721, -1.062632e-001, 1.406184e-001, 2.319818e-002
8722, -1.066196e-001, 1.425910e-001, 2.319815e-002
8723, -1.067977e-001, 1.435773e-001, 2.319820e-002
8724, -1.084010e-001, 1.524539e-001, 2.319840e-002
8725, -1.085786e-001, 1.534404e-001, 2.319885e-002
8726, -9.123323e-002, 2.109950e-002, 2.272499e-002
8727, -1.064414e-001, 1.416047e-001, 2.319816e-002
8728, -8.843288e-002, 2.159922e-002, 2.200002e-002
8729, -1.091042e-001, 1.564112e-001, 2.320701e-002
8730, -1.092727e-001, 1.574106e-001, 2.321600e-002
8731, -1.075104e-001, 1.475224e-001, 2.319817e-002
8732, -1.076885e-001, 1.485087e-001, 2.319823e-002
8733, -1.094366e-001, 1.584083e-001, 2.322821e-002
8734, -1.095989e-001, 1.593977e-001, 2.324054e-002
8735, -1.080449e-001, 1.504812e-001, 2.319819e-002
8736, -1.082230e-001, 1.514676e-001, 2.319829e-002
8737, -1.078668e-001, 1.494950e-001, 2.319816e-002
8738, -9.204896e-002, 2.095681e-002, 2.326662e-002
8739, -1.069758e-001, 1.445636e-001, 2.319823e-002
8740, -1.041252e-001, 1.287830e-001, 2.319811e-002
8741, -1.043033e-001, 1.297693e-001, 2.319820e-002
8742, -1.046596e-001, 1.317418e-001, 2.319820e-002
8743, -1.048377e-001, 1.327282e-001, 2.319827e-002
8744, -1.057286e-001, 1.376596e-001, 2.319826e-002
8745, -1.044814e-001, 1.307556e-001, 2.319822e-002
8746, -1.037689e-001, 1.268104e-001, 2.319813e-002
8747, -1.039470e-001, 1.277967e-001, 2.319819e-002
8748, -1.035907e-001, 1.258241e-001, 2.319815e-002
8749, -1.034125e-001, 1.248378e-001, 2.319814e-002
8750, -1.032342e-001, 1.238516e-001, 2.319823e-002
8751, -1.030561e-001, 1.228653e-001, 2.319822e-002
8752, -1.028779e-001, 1.218790e-001, 2.319818e-002
8753, -1.026998e-001, 1.208927e-001, 2.319815e-002
8754, -1.025216e-001, 1.199064e-001, 2.319817e-002
8755, -1.023434e-001, 1.189202e-001, 2.319819e-002
8756, -1.021652e-001, 1.179339e-001, 2.319819e-002
8757, -1.019871e-001, 1.169476e-001, 2.319819e-002
8758, -1.018089e-001, 1.159613e-001, 2.319820e-002
8759, -1.016307e-001, 1.149750e-001, 2.319819e-002
8760, -1.014525e-001, 1.139887e-001, 2.319819e-002
8761, -1.012744e-001, 1.130024e-001, 2.319820e-002
8762, -1.010962e-001, 1.120162e-001, 2.319821e-002
8763, -1.009180e-001, 1.110299e-001, 2.319821e-002
8764, -1.007398e-001, 1.100436e-001, 2.319821e-002
8765, -1.005617e-001, 1.090573e-001, 2.319821e-002
8766, -1.003835e-001, 1.080710e-001, 2.319821e-002
8767, -1.002053e-001, 1.070847e-001, 2.319821e-002
8768, -1.000271e-001, 1.060985e-001, 2.319821e-002
8769, -9.984896e-002, 1.051122e-001, 2.319821e-002
8770, -9.967079e-002, 1.041259e-001, 2.319821e-002
8771, -9.949262e-002, 1.031396e-001, 2.319821e-002
8772, -9.931444e-002, 1.021533e-001, 2.319821e-002
8773, -9.913627e-002, 1.011670e-001, 2.319821e-002
8774, -9.895810e-002, 1.001808e-001, 2.319821e-002
8775, -9.877993e-002, 9.919447e-002, 2.319821e-002
8776, -9.860175e-002, 9.820819e-002, 2.319821e-002
8777, -9.842358e-002, 9.722190e-002, 2.319821e-002
8778, -9.824541e-002, 9.623562e-002, 2.319821e-002
8779, -9.806724e-002, 9.524934e-002, 2.319821e-002
8780, -9.788906e-002, 9.426305e-002, 2.319821e-002
8781, -9.771089e-002, 9.327677e-002, 2.319821e-002
8782, -9.753272e-002, 9.229048e-002, 2.319821e-002
8783, -9.735454e-002, 9.130420e-002, 2.319821e-002
8784, -9.717637e-002, 9.031792e-002, 2.319821e-002
8785, -9.699820e-002, 8.933163e-002, 2.319821e-002
8786, -9.682003e-002, 8.834535e-002, 2.319821e-002
8787, -9.664185e-002, 8.735906e-002, 2.319821e-002
8788, -9.646368e-002, 8.637278e-002, 2.319821e-002
8789, -9.628551e-002, 8.538650e-002, 2.319821e-002
8790, -9.610734e-002, 8.440021e-002, 2.319821e-002
8791, -9.592916e-002, 8.341393e-002, 2.319821e-002
8792, -9.575099e-002, 8.242764e-002, 2.319821e-002
8793, -9.557282e-002, 8.144136e-002, 2.319821e-002
8794, -9.539465e-002, 8.045507e-002, 2.319821e-002
8795, -9.521647e-002, 7.946879e-002, 2.319821e-002
8796, -9.503830e-002, 7.848251e-002, 2.319821e-002
8797, -9.486013e-002, 7.749622e-002, 2.319821e-002
8798, -9.468196e-002, 7.650994e-002, 2.319821e-002
8799, -9.450378e-002, 7.552365e-002, 2.319821e-002
8800, -9.432561e-002, 7.453737e-002, 2.319821e-002
8801, -9.414744e-002, 7.355109e-002, 2.319821e-002
8802, -9.396927e-002, 7.256480e-002, 2.319821e-002
8803, -9.379109e-002, 7.157852e-002, 2.319821e-002
8804, -9.361292e-002, 7.059223e-002, 2.319821e-002
8805, -9.343475e-002, 6.960595e-002, 2.319821e-002
8806, -9.325658e-002, 6.861966e-002, 2.319821e-002
8807, -9.307840e-002, 6.763338e-002, 2.319821e-002
8808, -9.290023e-002, 6.664710e-002, 2.319821e-002
8809, -9.272206e-002, 6.566081e-002, 2.319821e-002
8810, -9.254389e-002, 6.467453e-002, 2.319821e-002
8811, -9.236571e-002, 6.368824e-002, 2.319821e-002
8812, -9.218754e-002, 6.270196e-002, 2.319821e-002
8813, -9.200937e-002, 6.171568e-002, 2.319821e-002
8814, -9.183120e-002, 6.072939e-002, 2.319821e-002
8815, -9.165302e-002, 5.974311e-002, 2.319821e-002
8816, -9.147485e-002, 5.875682e-002, 2.319821e-002
8817, -9.129668e-002, 5.777054e-002, 2.319821e-002
8818, -9.111850e-002, 5.678425e-002, 2.319821e-002
8819, -9.094033e-002, 5.579797e-002, 2.319821e-002
8820, -9.076216e-002, 5.481169e-002, 2.319821e-002
8821, -9.058399e-002, 5.382540e-002, 2.319821e-002
8822, -9.040581e-002, 5.283912e-002, 2.319821e-002
8823, -9.022764e-002, 5.185283e-002, 2.319821e-002
8824, -9.004947e-002, 5.086655e-002, 2.319821e-002
8825, -8.987130e-002, 4.988027e-002, 2.319821e-002
8826, -8.969312e-002, 4.889398e-002, 2.319821e-002
8827, -8.951495e-002, 4.790770e-002, 2.319821e-002
8828, -8.933678e-002, 4.692141e-002, 2.319821e-002
8829, -8.915861e-002, 4.593513e-002, 2.319821e-002
8830, -8.898043e-002, 4.494884e-002, 2.319821e-002
8831, -8.880226e-002, 4.396256e-002, 2.319821e-002
8832, -8.862409e-002, 4.297628e-002, 2.319821e-002
8833, -8.844592e-002, 4.198999e-002, 2.319821e-002
8834, -8.826774e-002, 4.100371e-002, 2.319821e-002
8835, -8.808957e-002, 4.001742e-002, 2.319821e-002
8836, -8.791140e-002, 3.903114e-002, 2.319821e-002
8837, -8.773323e-002, 3.804486e-002, 2.319821e-002
8838, -8.755505e-002, 3.705857e-002, 2.319821e-002
8839, -8.737688e-002, 3.607229e-002, 2.319821e-002
8840, -8.719871e-002, 3.508600e-002, 2.319821e-002
8841, -8.702054e-002, 3.409972e-002, 2.319821e-002
8842, -8.684236e-002, 3.311344e-002, 2.319821e-002
8843, -8.666419e-002, 3.212715e-002, 2.319821e-002
8844, -8.648602e-002, 3.114087e-002, 2.319821e-002
8845, -8.630785e-002, 3.015458e-002, 2.319821e-002
8846, -8.612967e-002, 2.916829e-002, 2.319821e-002
8847, -8.595120e-002, 2.818198e-002, 2.319843e-002
8848, -8.577165e-002, 2.719556e-002, 2.319943e-002
8849, -8.559012e-002, 2.620885e-002, 2.320185e-002
8850, -8.540598e-002, 2.522175e-002, 2.320615e-002
8851, -8.521878e-002, 2.423425e-002, 2.321269e-002
8852, -8.502842e-002, 2.324651e-002, 2.322158e-002
8853, -1.071540e-001, 1.455498e-001, 2.319821e-002
8854, -1.073323e-001, 1.465361e-001, 2.319818e-002
8855, -1.087551e-001, 1.544279e-001, 2.320028e-002
8856, -1.089298e-001, 1.554179e-001, 2.320331e-002
8857, -8.746888e-002, 2.177438e-002, 2.207816e-002
8858, -8.653220e-002, 2.194574e-002, 2.231466e-002
8859, -1.168177e-001, 1.580753e-001, 2.326525e-002
8860, -1.166392e-001, 1.570871e-001, 2.326528e-002
8861, -1.164604e-001, 1.560971e-001, 2.326530e-002
8862, -1.162817e-001, 1.551077e-001, 2.326534e-002
8863, -1.161034e-001, 1.541195e-001, 2.326548e-002
8864, -1.159254e-001, 1.531322e-001, 2.326583e-002
8865, -1.157478e-001, 1.521454e-001, 2.326631e-002
8866, -1.155701e-001, 1.511588e-001, 2.326673e-002
8867, -1.153923e-001, 1.501724e-001, 2.326701e-002
8868, -1.152143e-001, 1.491861e-001, 2.326716e-002
8869, -1.150362e-001, 1.481998e-001, 2.326723e-002
8870, -1.148581e-001, 1.472135e-001, 2.326724e-002
8871, -1.146799e-001, 1.462272e-001, 2.326723e-002
8872, -1.145017e-001, 1.452409e-001, 2.326723e-002
8873, -1.143236e-001, 1.442546e-001, 2.326724e-002
8874, -1.141454e-001, 1.432684e-001, 2.326726e-002
8875, -1.139672e-001, 1.422821e-001, 2.326725e-002
8876, -1.137890e-001, 1.412958e-001, 2.326723e-002
8877, -1.136109e-001, 1.403095e-001, 2.326724e-002
8878, -1.134327e-001, 1.393232e-001, 2.326725e-002
8879, -1.132545e-001, 1.383369e-001, 2.326724e-002
8880, -1.130763e-001, 1.373507e-001, 2.326723e-002
8881, -1.128982e-001, 1.363644e-001, 2.326723e-002
8882, -1.127200e-001, 1.353781e-001, 2.326724e-002
8883, -1.125418e-001, 1.343918e-001, 2.326725e-002
8884, -1.123637e-001, 1.334055e-001, 2.326726e-002
8885, -1.121855e-001, 1.324192e-001, 2.326725e-002
8886, -1.120073e-001, 1.314329e-001, 2.326725e-002
8887, -1.118291e-001, 1.304467e-001, 2.326723e-002
8888, -1.116510e-001, 1.294604e-001, 2.326723e-002
8889, -1.114728e-001, 1.284741e-001, 2.326723e-002
8890, -1.112946e-001, 1.274878e-001, 2.326725e-002
8891, -1.111165e-001, 1.265015e-001, 2.326726e-002
8892, -1.109383e-001, 1.255152e-001, 2.326725e-002
8893, -1.107601e-001, 1.245290e-001, 2.326726e-002
8894, -1.105819e-001, 1.235427e-001, 2.326725e-002
8895, -1.104037e-001, 1.225564e-001, 2.326723e-002
8896, -1.102256e-001, 1.215701e-001, 2.326724e-002
8897, -1.100474e-001, 1.205838e-001, 2.326726e-002
8898, -1.098693e-001, 1.195975e-001, 2.326725e-002
8899, -1.096911e-001, 1.186113e-001, 2.326723e-002
8900, -1.095129e-001, 1.176250e-001, 2.326723e-002
8901, -1.093347e-001, 1.166387e-001, 2.326724e-002
8902, -1.091566e-001, 1.156524e-001, 2.326725e-002
8903, -1.089784e-001, 1.146661e-001, 2.326725e-002
8904, -1.088002e-001, 1.136798e-001, 2.326726e-002
8905, -1.086221e-001, 1.126935e-001, 2.326726e-002
8906, -1.084439e-001, 1.117073e-001, 2.326725e-002
8907, -1.082657e-001, 1.107210e-001, 2.326724e-002
8908, -1.080875e-001, 1.097347e-001, 2.326724e-002
8909, -1.079093e-001, 1.087484e-001, 2.326724e-002
8910, -1.077312e-001, 1.077621e-001, 2.326724e-002
8911, -1.075530e-001, 1.067758e-001, 2.326724e-002
8912, -1.073748e-001, 1.057896e-001, 2.326724e-002
8913, -1.071966e-001, 1.048033e-001, 2.326724e-002
8914, -1.070185e-001, 1.038170e-001, 2.326724e-002
8915, -1.068403e-001, 1.028307e-001, 2.326724e-002
8916, -1.066621e-001, 1.018444e-001, 2.326724e-002
8917, -1.064840e-001, 1.008581e-001, 2.326724e-002
8918, -1.063058e-001, 9.987185e-002, 2.326724e-002
8919, -1.061276e-001, 9.888557e-002, 2.326724e-002
8920, -1.059494e-001, 9.789928e-002, 2.326724e-002
8921, -1.057713e-001, 9.691300e-002, 2.326724e-002
8922, -1.055931e-001, 9.592672e-002, 2.326724e-002
8923, -1.054149e-001, 9.494043e-002, 2.326724e-002
8924, -1.052367e-001, 9.395415e-002, 2.326724e-002
8925, -1.050586e-001, 9.296786e-002, 2.326724e-002
8926, -1.048804e-001, 9.198158e-002, 2.326724e-002
8927, -1.047022e-001, 9.099530e-002, 2.326724e-002
8928, -1.045241e-001, 9.000901e-002, 2.326724e-002
8929, -1.043459e-001, 8.902273e-002, 2.326724e-002
8930, -1.041677e-001, 8.803644e-002, 2.326724e-002
8931, -1.039895e-001, 8.705016e-002, 2.326724e-002
8932, -1.038114e-001, 8.606387e-002, 2.326724e-002
8933, -1.036332e-001, 8.507759e-002, 2.326724e-002
8934, -1.034550e-001, 8.409131e-002, 2.326724e-002
8935, -1.032768e-001, 8.310502e-002, 2.326724e-002
8936, -1.030987e-001, 8.211874e-002, 2.326724e-002
8937, -1.029205e-001, 8.113245e-002, 2.326724e-002
8938, -1.027423e-001, 8.014617e-002, 2.326724e-002
8939, -1.025642e-001, 7.915989e-002, 2.326724e-002
8940, -1.023860e-001, 7.817360e-002, 2.326724e-002
8941, -1.022078e-001, 7.718732e-002, 2.326724e-002
8942, -1.020296e-001, 7.620103e-002, 2.326724e-002
8943, -1.018515e-001, 7.521475e-002, 2.326724e-002
8944, -1.016733e-001, 7.422846e-002, 2.326724e-002
8945, -1.014951e-001, 7.324218e-002, 2.326724e-002
8946, -1.013170e-001, 7.225590e-002, 2.326724e-002
8947, -1.011388e-001, 7.126961e-002, 2.326724e-002
8948, -1.009606e-001, 7.028333e-002, 2.326724e-002
8949, -1.007824e-001, 6.929704e-002, 2.326724e-002
8950, -1.006043e-001, 6.831076e-002, 2.326724e-002
8951, -1.004261e-001, 6.732448e-002, 2.326724e-002
8952, -1.002479e-001, 6.633819e-002, 2.326724e-002
8953, -1.000697e-001, 6.535191e-002, 2.326724e-002
8954, -9.989157e-002, 6.436562e-002, 2.326724e-002
8955, -9.971340e-002, 6.337934e-002, 2.326724e-002
8956, -9.953522e-002, 6.239305e-002, 2.326724e-002
8957, -9.935705e-002, 6.140677e-002, 2.326724e-002
8958, -9.917888e-002, 6.042049e-002, 2.326724e-002
8959, -9.900071e-002, 5.943420e-002, 2.326724e-002
8960, -9.882253e-002, 5.844792e-002, 2.326724e-002
8961, -9.864436e-002, 5.746163e-002, 2.326724e-002
8962, -9.846619e-002, 5.647535e-002, 2.326724e-002
8963, -9.828802e-002, 5.548907e-002, 2.326724e-002
8964, -9.810984e-002, 5.450278e-002, 2.326724e-002
8965, -9.793167e-002, 5.351650e-002, 2.326724e-002
8966, -9.775350e-002, 5.253021e-002, 2.326724e-002
8967, -9.757533e-002, 5.154393e-002, 2.326724e-002
8968, -9.739715e-002, 5.055764e-002, 2.326724e-002
8969, -9.721898e-002, 4.957136e-002, 2.326724e-002
8970, -9.704081e-002, 4.858508e-002, 2.326724e-002
8971, -9.686264e-002, 4.759879e-002, 2.326724e-002
8972, -9.668446e-002, 4.661251e-002, 2.326724e-002
8973, -9.650629e-002, 4.562622e-002, 2.326724e-002
8974, -9.632812e-002, 4.463994e-002, 2.326724e-002
8975, -9.614995e-002, 4.365366e-002, 2.326724e-002
8976, -9.597177e-002, 4.266737e-002, 2.326724e-002
8977, -9.579360e-002, 4.168109e-002, 2.326724e-002
8978, -9.561543e-002, 4.069480e-002, 2.326724e-002
8979, -9.543726e-002, 3.970852e-002, 2.326724e-002
8980, -9.525908e-002, 3.872224e-002, 2.326724e-002
8981, -9.508091e-002, 3.773595e-002, 2.326724e-002
8982, -9.490274e-002, 3.674967e-002, 2.326724e-002
8983, -9.472457e-002, 3.576338e-002, 2.326724e-002
8984, -9.454639e-002, 3.477710e-002, 2.326724e-002
8985, -9.436822e-002, 3.379081e-002, 2.326724e-002
8986, -9.419005e-002, 3.280453e-002, 2.326724e-002
8987, -9.401188e-002, 3.181825e-002, 2.326724e-002
8988, -9.383370e-002, 3.083196e-002, 2.326724e-002
8989, -9.365553e-002, 2.984568e-002, 2.326724e-002
8990, -9.347736e-002, 2.885939e-002, 2.326724e-002
8991, -9.329919e-002, 2.787311e-002, 2.326724e-002
8992, -9.312092e-002, 2.688680e-002, 2.326717e-002
8993, -9.294236e-002, 2.590030e-002, 2.326690e-002
8994, -9.276354e-002, 2.491325e-002, 2.326651e-002
8995, -9.258465e-002, 2.392525e-002, 2.326620e-002
8996, -9.240580e-002, 2.293614e-002, 2.326607e-002
8997, -9.222718e-002, 2.194637e-002, 2.326621e-002
8998, -1.104128e-001, 1.592562e-001, 2.270792e-002
8999, -1.113009e-001, 1.590967e-001, 2.231720e-002
9000, -1.122402e-001, 1.589261e-001, 2.207900e-002
9001, -1.132058e-001, 1.587494e-001, 2.200001e-002
9002, -1.141721e-001, 1.585711e-001, 2.208288e-002
9003, -1.151131e-001, 1.583959e-001, 2.232606e-002
9004, -1.160032e-001, 1.582289e-001, 2.272365e-002
9005, -1.058466e-001, 1.335644e-001, 2.266914e-002
9006, -1.060244e-001, 1.345507e-001, 2.266934e-002
9007, -1.094051e-001, 1.532914e-001, 2.267180e-002
9008, -1.095778e-001, 1.542804e-001, 2.267482e-002
9009, -1.063806e-001, 1.365233e-001, 2.266941e-002
9010, -1.065583e-001, 1.375097e-001, 2.266966e-002
9011, -8.583868e-002, 2.309567e-002, 2.269574e-002
9012, -1.072719e-001, 1.414547e-001, 2.266919e-002
9013, -1.074495e-001, 1.424410e-001, 2.266948e-002
9014, -1.076274e-001, 1.434274e-001, 2.266963e-002
9015, -1.081626e-001, 1.463861e-001, 2.266927e-002
9016, -1.083401e-001, 1.473725e-001, 2.266962e-002
9017, -9.141165e-002, 2.208900e-002, 2.272481e-002
9018, -9.052126e-002, 2.224602e-002, 2.232730e-002
9019, -1.078054e-001, 1.444137e-001, 2.266974e-002
9020, -1.079836e-001, 1.454000e-001, 2.266968e-002
9021, -8.958195e-002, 2.241362e-002, 2.208400e-002
9022, -8.861895e-002, 2.258706e-002, 2.200004e-002
9023, -1.099199e-001, 1.562679e-001, 2.268352e-002
9024, -1.100857e-001, 1.572677e-001, 2.269115e-002
9025, -1.092288e-001, 1.523045e-001, 2.267078e-002
9026, -1.090523e-001, 1.513178e-001, 2.266987e-002
9027, -1.097488e-001, 1.552725e-001, 2.267903e-002
9028, -1.086972e-001, 1.493449e-001, 2.266922e-002
9029, -1.088742e-001, 1.503314e-001, 2.266983e-002
9030, -1.042427e-001, 1.246879e-001, 2.266935e-002
9031, -1.044207e-001, 1.256742e-001, 2.266942e-002
9032, -1.062020e-001, 1.355371e-001, 2.266963e-002
9033, -1.102495e-001, 1.582646e-001, 2.269966e-002
9034, -1.067364e-001, 1.384960e-001, 2.266970e-002
9035, -1.040637e-001, 1.237017e-001, 2.266975e-002
9036, -1.045989e-001, 1.266605e-001, 2.266939e-002
9037, -1.047770e-001, 1.276468e-001, 2.266945e-002
9038, -1.038857e-001, 1.227154e-001, 2.266965e-002
9039, -1.037079e-001, 1.217291e-001, 2.266947e-002
9040, -1.035300e-001, 1.207427e-001, 2.266933e-002
9041, -1.033517e-001, 1.197565e-001, 2.266941e-002
9042, -1.031733e-001, 1.187702e-001, 2.266949e-002
9043, -1.029951e-001, 1.177839e-001, 2.266951e-002
9044, -1.028169e-001, 1.167977e-001, 2.266952e-002
9045, -1.026388e-001, 1.158114e-001, 2.266953e-002
9046, -1.024606e-001, 1.148251e-001, 2.266951e-002
9047, -1.022824e-001, 1.138388e-001, 2.266953e-002
9048, -1.021042e-001, 1.128525e-001, 2.266955e-002
9049, -1.019260e-001, 1.118662e-001, 2.266957e-002
9050, -1.017478e-001, 1.108800e-001, 2.266959e-002
9051, -1.015696e-001, 1.098937e-001, 2.266960e-002
9052, -1.013914e-001, 1.089074e-001, 2.266960e-002
9053, -1.012132e-001, 1.079211e-001, 2.266960e-002
9054, -1.010351e-001, 1.069348e-001, 2.266960e-002
9055, -1.008569e-001, 1.059485e-001, 2.266960e-002
9056, -1.006787e-001, 1.049623e-001, 2.266960e-002
9057, -1.005005e-001, 1.039760e-001, 2.266960e-002
9058, -1.003224e-001, 1.029897e-001, 2.266960e-002
9059, -1.001442e-001, 1.020034e-001, 2.266960e-002
9060, -9.996603e-002, 1.010171e-001, 2.266960e-002
9061, -9.978785e-002, 1.000308e-001, 2.266960e-002
9062, -9.960968e-002, 9.904456e-002, 2.266960e-002
9063, -9.943151e-002, 9.805827e-002, 2.266960e-002
9064, -9.925333e-002, 9.707199e-002, 2.266960e-002
9065, -9.907516e-002, 9.608571e-002, 2.266960e-002
9066, -9.889699e-002, 9.509942e-002, 2.266960e-002
9067, -9.871882e-002, 9.411314e-002, 2.266960e-002
9068, -9.854064e-002, 9.312685e-002, 2.266960e-002
9069, -9.836247e-002, 9.214057e-002, 2.266960e-002
9070, -9.818430e-002, 9.115429e-002, 2.266960e-002
9071, -9.800613e-002, 9.016800e-002, 2.266960e-002
9072, -9.782795e-002, 8.918172e-002, 2.266960e-002
9073, -9.764978e-002, 8.819543e-002, 2.266960e-002
9074, -9.747161e-002, 8.720915e-002, 2.266960e-002
9075, -9.729344e-002, 8.622286e-002, 2.266960e-002
9076, -9.711526e-002, 8.523658e-002, 2.266960e-002
9077, -9.693709e-002, 8.425030e-002, 2.266960e-002
9078, -9.675892e-002, 8.326401e-002, 2.266960e-002
9079, -9.658075e-002, 8.227773e-002, 2.266960e-002
9080, -9.640257e-002, 8.129144e-002, 2.266960e-002
9081, -9.622440e-002, 8.030516e-002, 2.266960e-002
9082, -9.604623e-002, 7.931888e-002, 2.266960e-002
9083, -9.586806e-002, 7.833259e-002, 2.266960e-002
9084, -9.568988e-002, 7.734631e-002, 2.266960e-002
9085, -9.551171e-002, 7.636002e-002, 2.266960e-002
9086, -9.533354e-002, 7.537374e-002, 2.266960e-002
9087, -9.515537e-002, 7.438746e-002, 2.266960e-002
9088, -9.497719e-002, 7.340117e-002, 2.266960e-002
9089, -9.479902e-002, 7.241489e-002, 2.266960e-002
9090, -9.462085e-002, 7.142860e-002, 2.266960e-002
9091, -9.444268e-002, 7.044232e-002, 2.266960e-002
9092, -9.426450e-002, 6.945603e-002, 2.266960e-002
9093, -9.408633e-002, 6.846975e-002, 2.266960e-002
9094, -9.390816e-002, 6.748347e-002, 2.266960e-002
9095, -9.372999e-002, 6.649718e-002, 2.266960e-002
9096, -9.355181e-002, 6.551090e-002, 2.266960e-002
9097, -9.337364e-002, 6.452461e-002, 2.266960e-002
9098, -9.319547e-002, 6.353833e-002, 2.266960e-002
9099, -9.301729e-002, 6.255205e-002, 2.266960e-002
9100, -9.283912e-002, 6.156576e-002, 2.266960e-002
9101, -9.266095e-002, 6.057948e-002, 2.266960e-002
9102, -9.248278e-002, 5.959319e-002, 2.266960e-002
9103, -9.230460e-002, 5.860691e-002, 2.266960e-002
9104, -9.212643e-002, 5.762062e-002, 2.266960e-002
9105, -9.194826e-002, 5.663434e-002, 2.266960e-002
9106, -9.177009e-002, 5.564806e-002, 2.266960e-002
9107, -9.159191e-002, 5.466177e-002, 2.266960e-002
9108, -9.141374e-002, 5.367549e-002, 2.266960e-002
9109, -9.123557e-002, 5.268920e-002, 2.266960e-002
9110, -9.105740e-002, 5.170292e-002, 2.266960e-002
9111, -9.087922e-002, 5.071664e-002, 2.266960e-002
9112, -9.070105e-002, 4.973035e-002, 2.266960e-002
9113, -9.052288e-002, 4.874407e-002, 2.266960e-002
9114, -9.034471e-002, 4.775778e-002, 2.266960e-002
9115, -9.016653e-002, 4.677150e-002, 2.266960e-002
9116, -8.998836e-002, 4.578521e-002, 2.266960e-002
9117, -8.981019e-002, 4.479893e-002, 2.266960e-002
9118, -8.963202e-002, 4.381265e-002, 2.266960e-002
9119, -8.945384e-002, 4.282636e-002, 2.266960e-002
9120, -8.927567e-002, 4.184008e-002, 2.266960e-002
9121, -8.909750e-002, 4.085379e-002, 2.266960e-002
9122, -8.891933e-002, 3.986751e-002, 2.266960e-002
9123, -8.874115e-002, 3.888123e-002, 2.266960e-002
9124, -8.856298e-002, 3.789494e-002, 2.266960e-002
9125, -8.838481e-002, 3.690866e-002, 2.266960e-002
9126, -8.820664e-002, 3.592237e-002, 2.266960e-002
9127, -8.802846e-002, 3.493609e-002, 2.266960e-002
9128, -8.785029e-002, 3.394981e-002, 2.266960e-002
9129, -8.767212e-002, 3.296352e-002, 2.266960e-002
9130, -8.749395e-002, 3.197724e-002, 2.266960e-002
9131, -8.731577e-002, 3.099095e-002, 2.266960e-002
9132, -8.713760e-002, 3.000466e-002, 2.266960e-002
9133, -8.695898e-002, 2.901837e-002, 2.266983e-002
9134, -8.677877e-002, 2.803203e-002, 2.267086e-002
9135, -8.659582e-002, 2.704545e-002, 2.267327e-002
9136, -8.640980e-002, 2.605844e-002, 2.267721e-002
9137, -8.622110e-002, 2.507101e-002, 2.268251e-002
9138, -8.603039e-002, 2.408337e-002, 2.268885e-002
9139, -1.085179e-001, 1.483589e-001, 2.266981e-002
9140, -1.070932e-001, 1.404685e-001, 2.266947e-002
9141, -8.765805e-002, 2.276178e-002, 2.207644e-002
9142, -8.672328e-002, 2.293291e-002, 2.231044e-002
9143, -1.049553e-001, 1.286330e-001, 2.266935e-002
9144, -1.158249e-001, 1.572404e-001, 2.272379e-002
9145, -1.156462e-001, 1.562492e-001, 2.272398e-002
9146, -1.154679e-001, 1.552581e-001, 2.272437e-002
9147, -1.152905e-001, 1.542683e-001, 2.272514e-002
9148, -1.151141e-001, 1.532798e-001, 2.272630e-002
9149, -1.149381e-001, 1.522921e-001, 2.272761e-002
9150, -1.147619e-001, 1.513050e-001, 2.272872e-002
9151, -1.145851e-001, 1.503183e-001, 2.272949e-002
9152, -1.144077e-001, 1.493318e-001, 2.272994e-002
9153, -1.142299e-001, 1.483454e-001, 2.273014e-002
9154, -1.140517e-001, 1.473591e-001, 2.273014e-002
9155, -1.138734e-001, 1.463729e-001, 2.273009e-002
9156, -1.136953e-001, 1.453866e-001, 2.273011e-002
9157, -1.135173e-001, 1.444003e-001, 2.273019e-002
9158, -1.133392e-001, 1.434140e-001, 2.273022e-002
9159, -1.131609e-001, 1.424277e-001, 2.273016e-002
9160, -1.129826e-001, 1.414414e-001, 2.273012e-002
9161, -1.128045e-001, 1.404551e-001, 2.273014e-002
9162, -1.126264e-001, 1.394689e-001, 2.273015e-002
9163, -1.124481e-001, 1.384826e-001, 2.273012e-002
9164, -1.122699e-001, 1.374963e-001, 2.273011e-002
9165, -1.120918e-001, 1.365100e-001, 2.273011e-002
9166, -1.119137e-001, 1.355237e-001, 2.273015e-002
9167, -1.117356e-001, 1.345374e-001, 2.273020e-002
9168, -1.115574e-001, 1.335511e-001, 2.273022e-002
9169, -1.113792e-001, 1.325648e-001, 2.273020e-002
9170, -1.112010e-001, 1.315786e-001, 2.273016e-002
9171, -1.110227e-001, 1.305923e-001, 2.273010e-002
9172, -1.108445e-001, 1.296060e-001, 2.273010e-002
9173, -1.106664e-001, 1.286197e-001, 2.273014e-002
9174, -1.104884e-001, 1.276334e-001, 2.273020e-002
9175, -1.103102e-001, 1.266471e-001, 2.273022e-002
9176, -1.101321e-001, 1.256609e-001, 2.273022e-002
9177, -1.099539e-001, 1.246746e-001, 2.273022e-002
9178, -1.097756e-001, 1.236883e-001, 2.273016e-002
9179, -1.095974e-001, 1.227020e-001, 2.273012e-002
9180, -1.094193e-001, 1.217157e-001, 2.273016e-002
9181, -1.092412e-001, 1.207294e-001, 2.273020e-002
9182, -1.090629e-001, 1.197432e-001, 2.273016e-002
9183, -1.088846e-001, 1.187569e-001, 2.273010e-002
9184, -1.087065e-001, 1.177706e-001, 2.273012e-002
9185, -1.085284e-001, 1.167843e-001, 2.273017e-002
9186, -1.083503e-001, 1.157980e-001, 2.273020e-002
9187, -1.081721e-001, 1.148117e-001, 2.273021e-002
9188, -1.079940e-001, 1.138254e-001, 2.273023e-002
9189, -1.078158e-001, 1.128392e-001, 2.273022e-002
9190, -1.076376e-001, 1.118529e-001, 2.273019e-002
9191, -1.074594e-001, 1.108666e-001, 2.273017e-002
9192, -1.072812e-001, 1.098803e-001, 2.273015e-002
9193, -1.071030e-001, 1.088940e-001, 2.273014e-002
9194, -1.069248e-001, 1.079078e-001, 2.273014e-002
9195, -1.067466e-001, 1.069215e-001, 2.273014e-002
9196, -1.065685e-001, 1.059352e-001, 2.273014e-002
9197, -1.063903e-001, 1.049489e-001, 2.273014e-002
9198, -1.062121e-001, 1.039626e-001, 2.273014e-002
9199, -1.060339e-001, 1.029763e-001, 2.273014e-002
9200, -1.058558e-001, 1.019900e-001, 2.273014e-002
9201, -1.056776e-001, 1.010038e-001, 2.273014e-002
9202, -1.054994e-001, 1.000175e-001, 2.273014e-002
9203, -1.053213e-001, 9.903120e-002, 2.273014e-002
9204, -1.051431e-001, 9.804491e-002, 2.273014e-002
9205, -1.049649e-001, 9.705863e-002, 2.273014e-002
9206, -1.047867e-001, 9.607234e-002, 2.273014e-002
9207, -1.046086e-001, 9.508606e-002, 2.273014e-002
9208, -1.044304e-001, 9.409978e-002, 2.273014e-002
9209, -1.042522e-001, 9.311349e-002, 2.273014e-002
9210, -1.040740e-001, 9.212721e-002, 2.273014e-002
9211, -1.038959e-001, 9.114092e-002, 2.273014e-002
9212, -1.037177e-001, 9.015464e-002, 2.273014e-002
9213, -1.035395e-001, 8.916836e-002, 2.273014e-002
9214, -1.033614e-001, 8.818207e-002, 2.273014e-002
9215, -1.031832e-001, 8.719579e-002, 2.273014e-002
9216, -1.030050e-001, 8.620950e-002, 2.273014e-002
9217, -1.028268e-001, 8.522322e-002, 2.273014e-002
9218, -1.026487e-001, 8.423694e-002, 2.273014e-002
9219, -1.024705e-001, 8.325065e-002, 2.273014e-002
9220, -1.022923e-001, 8.226437e-002, 2.273014e-002
9221, -1.021141e-001, 8.127808e-002, 2.273014e-002
9222, -1.019360e-001, 8.029180e-002, 2.273014e-002
9223, -1.017578e-001, 7.930551e-002, 2.273014e-002
9224, -1.015796e-001, 7.831923e-002, 2.273014e-002
9225, -1.014015e-001, 7.733295e-002, 2.273014e-002
9226, -1.012233e-001, 7.634666e-002, 2.273014e-002
9227, -1.010451e-001, 7.536038e-002, 2.273014e-002
9228, -1.008669e-001, 7.437409e-002, 2.273014e-002
9229, -1.006888e-001, 7.338781e-002, 2.273014e-002
9230, -1.005106e-001, 7.240153e-002, 2.273014e-002
9231, -1.003324e-001, 7.141524e-002, 2.273014e-002
9232, -1.001542e-001, 7.042896e-002, 2.273014e-002
9233, -9.997608e-002, 6.944267e-002, 2.273014e-002
9234, -9.979790e-002, 6.845639e-002, 2.273014e-002
9235, -9.961973e-002, 6.747010e-002, 2.273014e-002
9236, -9.944156e-002, 6.648382e-002, 2.273014e-002
9237, -9.926339e-002, 6.549754e-002, 2.273014e-002
9238, -9.908521e-002, 6.451125e-002, 2.273014e-002
9239, -9.890704e-002, 6.352497e-002, 2.273014e-002
9240, -9.872887e-002, 6.253868e-002, 2.273014e-002
9241, -9.855069e-002, 6.155240e-002, 2.273014e-002
9242, -9.837252e-002, 6.056612e-002, 2.273014e-002
9243, -9.819435e-002, 5.957983e-002, 2.273014e-002
9244, -9.801618e-002, 5.859355e-002, 2.273014e-002
9245, -9.783800e-002, 5.760726e-002, 2.273014e-002
9246, -9.765983e-002, 5.662098e-002, 2.273014e-002
9247, -9.748166e-002, 5.563469e-002, 2.273014e-002
9248, -9.730349e-002, 5.464841e-002, 2.273014e-002
9249, -9.712531e-002, 5.366213e-002, 2.273014e-002
9250, -9.694714e-002, 5.267584e-002, 2.273014e-002
9251, -9.676897e-002, 5.168956e-002, 2.273014e-002
9252, -9.659080e-002, 5.070327e-002, 2.273014e-002
9253, -9.641262e-002, 4.971699e-002, 2.273014e-002
9254, -9.623445e-002, 4.873071e-002, 2.273014e-002
9255, -9.605628e-002, 4.774442e-002, 2.273014e-002
9256, -9.587811e-002, 4.675814e-002, 2.273014e-002
9257, -9.569993e-002, 4.577185e-002, 2.273014e-002
9258, -9.552176e-002, 4.478557e-002, 2.273014e-002
9259, -9.534359e-002, 4.379929e-002, 2.273014e-002
9260, -9.516542e-002, 4.281300e-002, 2.273014e-002
9261, -9.498724e-002, 4.182672e-002, 2.273014e-002
9262, -9.480907e-002, 4.084043e-002, 2.273014e-002
9263, -9.463090e-002, 3.985415e-002, 2.273014e-002
9264, -9.445273e-002, 3.886786e-002, 2.273014e-002
9265, -9.427455e-002, 3.788158e-002, 2.273014e-002
9266, -9.409638e-002, 3.689530e-002, 2.273014e-002
9267, -9.391821e-002, 3.590901e-002, 2.273014e-002
9268, -9.374004e-002, 3.492273e-002, 2.273014e-002
9269, -9.356186e-002, 3.393644e-002, 2.273014e-002
9270, -9.338369e-002, 3.295016e-002, 2.273014e-002
9271, -9.320552e-002, 3.196388e-002, 2.273014e-002
9272, -9.302735e-002, 3.097759e-002, 2.273014e-002
9273, -9.284917e-002, 2.999131e-002, 2.273014e-002
9274, -9.267101e-002, 2.900502e-002, 2.273014e-002
9275, -9.249263e-002, 2.801872e-002, 2.273003e-002
9276, -9.231351e-002, 2.703228e-002, 2.272954e-002
9277, -9.213341e-002, 2.604532e-002, 2.272857e-002
9278, -9.195269e-002, 2.505747e-002, 2.272736e-002
9279, -9.177193e-002, 2.406858e-002, 2.272623e-002
9280, -9.159146e-002, 2.307893e-002, 2.272533e-002
9281, -1.069142e-001, 1.394823e-001, 2.266988e-002
9282, -1.053115e-001, 1.306056e-001, 2.266946e-002
9283, -1.054892e-001, 1.315920e-001, 2.266972e-002
9284, -1.056671e-001, 1.325783e-001, 2.266983e-002
9285, -1.051329e-001, 1.296194e-001, 2.266965e-002
9286, -1.111354e-001, 1.581048e-001, 2.231266e-002
9287, -1.120715e-001, 1.579343e-001, 2.207731e-002
9288, -1.130338e-001, 1.577580e-001, 2.200003e-002
9289, -1.139972e-001, 1.575802e-001, 2.208356e-002
9290, -1.149360e-001, 1.574058e-001, 2.232665e-002
9291, -1.102962e-001, 1.531310e-001, 2.229339e-002
9292, -1.104660e-001, 1.541212e-001, 2.229630e-002
9293, -1.099489e-001, 1.511558e-001, 2.229033e-002
9294, -1.101219e-001, 1.521434e-001, 2.229206e-002
9295, -1.058536e-001, 1.284707e-001, 2.228945e-002
9296, -1.060306e-001, 1.294572e-001, 2.228985e-002
9297, -1.081696e-001, 1.412925e-001, 2.228953e-002
9298, -1.083467e-001, 1.422789e-001, 2.228989e-002
9299, -1.067447e-001, 1.334021e-001, 2.228939e-002
9300, -1.069222e-001, 1.343885e-001, 2.228961e-002
9301, -8.691490e-002, 2.392050e-002, 2.230611e-002
9302, -1.106351e-001, 1.551141e-001, 2.229961e-002
9303, -1.108033e-001, 1.561103e-001, 2.230341e-002
9304, -1.090602e-001, 1.462239e-001, 2.228964e-002
9305, -1.092369e-001, 1.472105e-001, 2.229011e-002
9306, -1.088813e-001, 1.452378e-001, 2.228987e-002
9307, -1.079906e-001, 1.403063e-001, 2.228983e-002
9308, -9.070365e-002, 2.323586e-002, 2.232852e-002
9309, -1.095950e-001, 1.491828e-001, 2.228955e-002
9310, -1.097707e-001, 1.501695e-001, 2.229035e-002
9311, -1.085243e-001, 1.432653e-001, 2.229007e-002
9312, -1.087017e-001, 1.442518e-001, 2.229034e-002
9313, -1.044284e-001, 1.205804e-001, 2.228939e-002
9314, -1.046055e-001, 1.215669e-001, 2.228976e-002
9315, -1.070997e-001, 1.353749e-001, 2.228982e-002
9316, -1.072774e-001, 1.363613e-001, 2.228998e-002
9317, -1.109696e-001, 1.571080e-001, 2.230795e-002
9318, -1.074550e-001, 1.373477e-001, 2.229016e-002
9319, -1.076333e-001, 1.383339e-001, 2.229013e-002
9320, -1.047826e-001, 1.225534e-001, 2.229010e-002
9321, -1.054969e-001, 1.264982e-001, 2.228958e-002
9322, -1.056743e-001, 1.274847e-001, 2.228983e-002
9323, -8.880756e-002, 2.357562e-002, 2.200008e-002
9324, -8.784912e-002, 2.374999e-002, 2.207446e-002
9325, -1.053181e-001, 1.255120e-001, 2.228977e-002
9326, -1.042496e-001, 1.195943e-001, 2.228962e-002
9327, -1.040709e-001, 1.186081e-001, 2.228978e-002
9328, -1.038926e-001, 1.176218e-001, 2.228982e-002
9329, -1.037144e-001, 1.166355e-001, 2.228982e-002
9330, -1.035362e-001, 1.156492e-001, 2.228984e-002
9331, -1.033581e-001, 1.146629e-001, 2.228981e-002
9332, -1.031799e-001, 1.136766e-001, 2.228984e-002
9333, -1.030016e-001, 1.126904e-001, 2.228988e-002
9334, -1.028233e-001, 1.117041e-001, 2.228991e-002
9335, -1.026451e-001, 1.107178e-001, 2.228993e-002
9336, -1.024668e-001, 1.097316e-001, 2.228995e-002
9337, -1.022887e-001, 1.087453e-001, 2.228995e-002
9338, -1.021105e-001, 1.077590e-001, 2.228996e-002
9339, -1.019323e-001, 1.067727e-001, 2.228996e-002
9340, -1.017541e-001, 1.057864e-001, 2.228996e-002
9341, -1.015759e-001, 1.048001e-001, 2.228996e-002
9342, -1.013978e-001, 1.038139e-001, 2.228996e-002
9343, -1.012196e-001, 1.028276e-001, 2.228996e-002
9344, -1.010414e-001, 1.018413e-001, 2.228996e-002
9345, -1.008633e-001, 1.008550e-001, 2.228996e-002
9346, -1.006851e-001, 9.986872e-002, 2.228996e-002
9347, -1.005069e-001, 9.888244e-002, 2.228996e-002
9348, -1.003287e-001, 9.789615e-002, 2.228996e-002
9349, -1.001506e-001, 9.690987e-002, 2.228996e-002
9350, -9.997240e-002, 9.592358e-002, 2.228996e-002
9351, -9.979422e-002, 9.493730e-002, 2.228996e-002
9352, -9.961605e-002, 9.395102e-002, 2.228996e-002
9353, -9.943788e-002, 9.296473e-002, 2.228996e-002
9354, -9.925971e-002, 9.197845e-002, 2.228996e-002
9355, -9.908153e-002, 9.099216e-002, 2.228996e-002
9356, -9.890336e-002, 9.000588e-002, 2.228996e-002
9357, -9.872519e-002, 8.901960e-002, 2.228996e-002
9358, -9.854701e-002, 8.803331e-002, 2.228996e-002
9359, -9.836884e-002, 8.704703e-002, 2.228996e-002
9360, -9.819067e-002, 8.606074e-002, 2.228996e-002
9361, -9.801250e-002, 8.507446e-002, 2.228996e-002
9362, -9.783432e-002, 8.408817e-002, 2.228996e-002
9363, -9.765615e-002, 8.310189e-002, 2.228996e-002
9364, -9.747798e-002, 8.211561e-002, 2.228996e-002
9365, -9.729981e-002, 8.112932e-002, 2.228996e-002
9366, -9.712163e-002, 8.014304e-002, 2.228996e-002
9367, -9.694346e-002, 7.915675e-002, 2.228996e-002
9368, -9.676529e-002, 7.817047e-002, 2.228996e-002
9369, -9.658712e-002, 7.718419e-002, 2.228996e-002
9370, -9.640894e-002, 7.619790e-002, 2.228996e-002
9371, -9.623077e-002, 7.521162e-002, 2.228996e-002
9372, -9.605260e-002, 7.422533e-002, 2.228996e-002
9373, -9.587443e-002, 7.323905e-002, 2.228996e-002
9374, -9.569625e-002, 7.225277e-002, 2.228996e-002
9375, -9.551808e-002, 7.126648e-002, 2.228996e-002
9376, -9.533991e-002, 7.028020e-002, 2.228996e-002
9377, -9.516174e-002, 6.929391e-002, 2.228996e-002
9378, -9.498356e-002, 6.830763e-002, 2.228996e-002
9379, -9.480539e-002, 6.732134e-002, 2.228996e-002
9380, -9.462722e-002, 6.633506e-002, 2.228996e-002
9381, -9.444905e-002, 6.534878e-002, 2.228996e-002
9382, -9.427087e-002, 6.436249e-002, 2.228996e-002
9383, -9.409270e-002, 6.337621e-002, 2.228996e-002
9384, -9.391453e-002, 6.238992e-002, 2.228996e-002
9385, -9.373636e-002, 6.140364e-002, 2.228996e-002
9386, -9.355818e-002, 6.041736e-002, 2.228996e-002
9387, -9.338001e-002, 5.943107e-002, 2.228996e-002
9388, -9.320184e-002, 5.844479e-002, 2.228996e-002
9389, -9.302367e-002, 5.745850e-002, 2.228996e-002
9390, -9.284549e-002, 5.647222e-002, 2.228996e-002
9391, -9.266732e-002, 5.548593e-002, 2.228996e-002
9392, -9.248915e-002, 5.449965e-002, 2.228996e-002
9393, -9.231097e-002, 5.351337e-002, 2.228996e-002
9394, -9.213280e-002, 5.252708e-002, 2.228996e-002
9395, -9.195463e-002, 5.154080e-002, 2.228996e-002
9396, -9.177646e-002, 5.055451e-002, 2.228996e-002
9397, -9.159828e-002, 4.956823e-002, 2.228996e-002
9398, -9.142011e-002, 4.858195e-002, 2.228996e-002
9399, -9.124194e-002, 4.759566e-002, 2.228996e-002
9400, -9.106377e-002, 4.660938e-002, 2.228996e-002
9401, -9.088559e-002, 4.562309e-002, 2.228996e-002
9402, -9.070742e-002, 4.463681e-002, 2.228996e-002
9403, -9.052925e-002, 4.365052e-002, 2.228996e-002
9404, -9.035108e-002, 4.266424e-002, 2.228996e-002
9405, -9.017290e-002, 4.167796e-002, 2.228996e-002
9406, -8.999473e-002, 4.069167e-002, 2.228996e-002
9407, -8.981656e-002, 3.970539e-002, 2.228996e-002
9408, -8.963839e-002, 3.871910e-002, 2.228996e-002
9409, -8.946021e-002, 3.773282e-002, 2.228996e-002
9410, -8.928204e-002, 3.674654e-002, 2.228996e-002
9411, -8.910387e-002, 3.576025e-002, 2.228996e-002
9412, -8.892570e-002, 3.477397e-002, 2.228996e-002
9413, -8.874752e-002, 3.378768e-002, 2.228996e-002
9414, -8.856935e-002, 3.280140e-002, 2.228996e-002
9415, -8.839118e-002, 3.181511e-002, 2.228996e-002
9416, -8.821300e-002, 3.082883e-002, 2.228996e-002
9417, -8.803450e-002, 2.984255e-002, 2.229006e-002
9418, -8.785455e-002, 2.885630e-002, 2.229063e-002
9419, -8.767183e-002, 2.786994e-002, 2.229207e-002
9420, -8.748578e-002, 2.688321e-002, 2.229457e-002
9421, -8.729692e-002, 2.589602e-002, 2.229795e-002
9422, -8.710631e-002, 2.490847e-002, 2.230190e-002
9423, -1.094147e-001, 1.481968e-001, 2.229024e-002
9424, -1.078112e-001, 1.393203e-001, 2.229022e-002
9425, -1.062081e-001, 1.304436e-001, 2.229007e-002
9426, -8.976819e-002, 2.340304e-002, 2.208525e-002
9427, -1.051395e-001, 1.245258e-001, 2.228994e-002
9428, -1.147586e-001, 1.564139e-001, 2.232726e-002
9429, -1.145822e-001, 1.554214e-001, 2.232825e-002
9430, -1.144073e-001, 1.544300e-001, 2.232968e-002
9431, -1.142335e-001, 1.534401e-001, 2.233139e-002
9432, -1.140600e-001, 1.524514e-001, 2.233312e-002
9433, -1.138858e-001, 1.514636e-001, 2.233460e-002
9434, -1.137106e-001, 1.504764e-001, 2.233567e-002
9435, -1.135342e-001, 1.494896e-001, 2.233630e-002
9436, -1.133568e-001, 1.485032e-001, 2.233656e-002
9437, -1.131785e-001, 1.475169e-001, 2.233653e-002
9438, -1.130001e-001, 1.465306e-001, 2.233647e-002
9439, -1.128222e-001, 1.455443e-001, 2.233655e-002
9440, -1.126443e-001, 1.445579e-001, 2.233665e-002
9441, -1.124662e-001, 1.435717e-001, 2.233666e-002
9442, -1.122877e-001, 1.425854e-001, 2.233657e-002
9443, -1.121094e-001, 1.415992e-001, 2.233652e-002
9444, -1.119313e-001, 1.406129e-001, 2.233655e-002
9445, -1.117532e-001, 1.396266e-001, 2.233657e-002
9446, -1.115749e-001, 1.386403e-001, 2.233652e-002
9447, -1.113967e-001, 1.376540e-001, 2.233650e-002
9448, -1.112186e-001, 1.366677e-001, 2.233653e-002
9449, -1.110406e-001, 1.356814e-001, 2.233660e-002
9450, -1.108627e-001, 1.346951e-001, 2.233668e-002
9451, -1.106846e-001, 1.337088e-001, 2.233671e-002
9452, -1.105062e-001, 1.327225e-001, 2.233665e-002
9453, -1.103278e-001, 1.317363e-001, 2.233657e-002
9454, -1.101494e-001, 1.307501e-001, 2.233647e-002
9455, -1.099713e-001, 1.297638e-001, 2.233650e-002
9456, -1.097934e-001, 1.287774e-001, 2.233659e-002
9457, -1.096155e-001, 1.277911e-001, 2.233669e-002
9458, -1.094374e-001, 1.268048e-001, 2.233673e-002
9459, -1.092591e-001, 1.258185e-001, 2.233669e-002
9460, -1.090809e-001, 1.248323e-001, 2.233666e-002
9461, -1.089025e-001, 1.238460e-001, 2.233657e-002
9462, -1.087242e-001, 1.228598e-001, 2.233653e-002
9463, -1.085462e-001, 1.218734e-001, 2.233659e-002
9464, -1.083681e-001, 1.208871e-001, 2.233663e-002
9465, -1.081898e-001, 1.199009e-001, 2.233657e-002
9466, -1.080115e-001, 1.189146e-001, 2.233652e-002
9467, -1.078334e-001, 1.179283e-001, 2.233656e-002
9468, -1.076554e-001, 1.169420e-001, 2.233663e-002
9469, -1.074774e-001, 1.159557e-001, 2.233668e-002
9470, -1.072992e-001, 1.149694e-001, 2.233669e-002
9471, -1.071212e-001, 1.139831e-001, 2.233672e-002
9472, -1.069429e-001, 1.129968e-001, 2.233669e-002
9473, -1.067646e-001, 1.120105e-001, 2.233665e-002
9474, -1.065863e-001, 1.110243e-001, 2.233662e-002
9475, -1.064081e-001, 1.100380e-001, 2.233659e-002
9476, -1.062299e-001, 1.090517e-001, 2.233658e-002
9477, -1.060517e-001, 1.080654e-001, 2.233657e-002
9478, -1.058735e-001, 1.070792e-001, 2.233657e-002
9479, -1.056953e-001, 1.060929e-001, 2.233657e-002
9480, -1.055172e-001, 1.051066e-001, 2.233657e-002
9481, -1.053390e-001, 1.041203e-001, 2.233657e-002
9482, -1.051608e-001, 1.031340e-001, 2.233657e-002
9483, -1.049827e-001, 1.021477e-001, 2.233657e-002
9484, -1.048045e-001, 1.011615e-001, 2.233657e-002
9485, -1.046263e-001, 1.001752e-001, 2.233657e-002
9486, -1.044481e-001, 9.918889e-002, 2.233657e-002
9487, -1.042700e-001, 9.820260e-002, 2.233657e-002
9488, -1.040918e-001, 9.721632e-002, 2.233657e-002
9489, -1.039136e-001, 9.623004e-002, 2.233657e-002
9490, -1.037354e-001, 9.524375e-002, 2.233657e-002
9491, -1.035573e-001, 9.425747e-002, 2.233657e-002
9492, -1.033791e-001, 9.327118e-002, 2.233657e-002
9493, -1.032009e-001, 9.228490e-002, 2.233657e-002
9494, -1.030228e-001, 9.129861e-002, 2.233657e-002
9495, -1.028446e-001, 9.031233e-002, 2.233657e-002
9496, -1.026664e-001, 8.932605e-002, 2.233657e-002
9497, -1.024882e-001, 8.833976e-002, 2.233657e-002
9498, -1.023101e-001, 8.735348e-002, 2.233657e-002
9499, -1.021319e-001, 8.636719e-002, 2.233657e-002
9500, -1.019537e-001, 8.538091e-002, 2.233657e-002
9501, -1.017755e-001, 8.439463e-002, 2.233657e-002
9502, -1.015974e-001, 8.340834e-002, 2.233657e-002
9503, -1.014192e-001, 8.242206e-002, 2.233657e-002
9504, -1.012410e-001, 8.143577e-002, 2.233657e-002
9505, -1.010629e-001, 8.044949e-002, 2.233657e-002
9506, -1.008847e-001, 7.946320e-002, 2.233657e-002
9507, -1.007065e-001, 7.847692e-002, 2.233657e-002
9508, -1.005283e-001, 7.749064e-002, 2.233657e-002
9509, -1.003502e-001, 7.650435e-002, 2.233657e-002
9510, -1.001720e-001, 7.551807e-002, 2.233657e-002
9511, -9.999382e-002, 7.453178e-002, 2.233657e-002
9512, -9.981565e-002, 7.354550e-002, 2.233657e-002
9513, -9.963747e-002, 7.255922e-002, 2.233657e-002
9514, -9.945930e-002, 7.157293e-002, 2.233657e-002
9515, -9.928113e-002, 7.058665e-002, 2.233657e-002
9516, -9.910296e-002, 6.960036e-002, 2.233657e-002
9517, -9.892478e-002, 6.861408e-002, 2.233657e-002
9518, -9.874661e-002, 6.762780e-002, 2.233657e-002
9519, -9.856844e-002, 6.664151e-002, 2.233657e-002
9520, -9.839027e-002, 6.565523e-002, 2.233657e-002
9521, -9.821209e-002, 6.466894e-002, 2.233657e-002
9522, -9.803392e-002, 6.368266e-002, 2.233657e-002
9523, -9.785575e-002, 6.269637e-002, 2.233657e-002
9524, -9.767758e-002, 6.171009e-002, 2.233657e-002
9525, -9.749940e-002, 6.072381e-002, 2.233657e-002
9526, -9.732123e-002, 5.973752e-002, 2.233657e-002
9527, -9.714306e-002, 5.875124e-002, 2.233657e-002
9528, -9.696489e-002, 5.776495e-002, 2.233657e-002
9529, -9.678671e-002, 5.677867e-002, 2.233657e-002
9530, -9.660854e-002, 5.579239e-002, 2.233657e-002
9531, -9.643037e-002, 5.480610e-002, 2.233657e-002
9532, -9.625220e-002, 5.381982e-002, 2.233657e-002
9533, -9.607402e-002, 5.283353e-002, 2.233657e-002
9534, -9.589585e-002, 5.184725e-002, 2.233657e-002
9535, -9.571768e-002, 5.086096e-002, 2.233657e-002
9536, -9.553950e-002, 4.987468e-002, 2.233657e-002
9537, -9.536133e-002, 4.888840e-002, 2.233657e-002
9538, -9.518316e-002, 4.790211e-002, 2.233657e-002
9539, -9.500499e-002, 4.691583e-002, 2.233657e-002
9540, -9.482681e-002, 4.592954e-002, 2.233657e-002
9541, -9.464864e-002, 4.494326e-002, 2.233657e-002
9542, -9.447047e-002, 4.395698e-002, 2.233657e-002
9543, -9.429230e-002, 4.297069e-002, 2.233657e-002
9544, -9.411412e-002, 4.198441e-002, 2.233657e-002
9545, -9.393595e-002, 4.099812e-002, 2.233657e-002
9546, -9.375778e-002, 4.001184e-002, 2.233657e-002
9547, -9.357961e-002, 3.902555e-002, 2.233657e-002
9548, -9.340143e-002, 3.803927e-002, 2.233657e-002
9549, -9.322326e-002, 3.705299e-002, 2.233657e-002
9550, -9.304509e-002, 3.606670e-002, 2.233657e-002
9551, -9.286692e-002, 3.508042e-002, 2.233657e-002
9552, -9.268874e-002, 3.409413e-002, 2.233657e-002
9553, -9.251057e-002, 3.310785e-002, 2.233657e-002
9554, -9.233240e-002, 3.212157e-002, 2.233657e-002
9555, -9.215423e-002, 3.113528e-002, 2.233657e-002
9556, -9.197606e-002, 3.014900e-002, 2.233657e-002
9557, -9.179768e-002, 2.916271e-002, 2.233650e-002
9558, -9.161837e-002, 2.817639e-002, 2.233611e-002
9559, -9.143738e-002, 2.718979e-002, 2.233516e-002
9560, -9.125475e-002, 2.620252e-002, 2.233369e-002
9561, -9.107127e-002, 2.521435e-002, 2.233199e-002
9562, -9.088771e-002, 2.422537e-002, 2.233032e-002
9563, -1.063857e-001, 1.314300e-001, 2.229027e-002
9564, -1.049597e-001, 1.235399e-001, 2.229047e-002
9565, -1.065639e-001, 1.324163e-001, 2.229024e-002
9566, -1.119034e-001, 1.569383e-001, 2.207544e-002
9567, -1.128627e-001, 1.567630e-001, 2.200006e-002
9568, -1.138230e-001, 1.565864e-001, 2.208445e-002
9569, -1.108848e-001, 1.509868e-001, 2.206680e-002
9570, -1.110568e-001, 1.519747e-001, 2.206776e-002
9571, -1.105324e-001, 1.490134e-001, 2.206619e-002
9572, -1.107076e-001, 1.500003e-001, 2.206665e-002
9573, -1.087501e-001, 1.391506e-001, 2.206628e-002
9574, -1.089282e-001, 1.401369e-001, 2.206630e-002
9575, -1.076823e-001, 1.332327e-001, 2.206610e-002
9576, -1.078600e-001, 1.342191e-001, 2.206617e-002
9577, -1.075020e-001, 1.322468e-001, 2.206642e-002
9578, -1.066132e-001, 1.273150e-001, 2.206611e-002
9579, -1.067907e-001, 1.283014e-001, 2.206620e-002
9580, -1.112281e-001, 1.529634e-001, 2.206885e-002
9581, -1.117355e-001, 1.559416e-001, 2.207353e-002
9582, -1.085707e-001, 1.381646e-001, 2.206646e-002
9583, -1.115671e-001, 1.549466e-001, 2.207178e-002
9584, -1.091062e-001, 1.411233e-001, 2.206632e-002
9585, -1.098194e-001, 1.450683e-001, 2.206624e-002
9586, -1.099965e-001, 1.460548e-001, 2.206640e-002
9587, -1.113976e-001, 1.539541e-001, 2.207029e-002
9588, -1.080373e-001, 1.352055e-001, 2.206629e-002
9589, -1.082146e-001, 1.361920e-001, 2.206643e-002
9590, -1.051877e-001, 1.194248e-001, 2.206613e-002
9591, -1.053654e-001, 1.204111e-001, 2.206620e-002
9592, -1.092838e-001, 1.421096e-001, 2.206641e-002
9593, -1.094617e-001, 1.430960e-001, 2.206644e-002
9594, -1.060775e-001, 1.243564e-001, 2.206629e-002
9595, -1.062555e-001, 1.253427e-001, 2.206631e-002
9596, -8.995523e-002, 2.439212e-002, 2.208666e-002
9597, -1.050086e-001, 1.184386e-001, 2.206626e-002
9598, -1.096394e-001, 1.440823e-001, 2.206652e-002
9599, -1.055429e-001, 1.213975e-001, 2.206629e-002
9600, -8.899808e-002, 2.456449e-002, 2.200016e-002
9601, -8.804033e-002, 2.473828e-002, 2.207249e-002
9602, -1.083916e-001, 1.371785e-001, 2.206661e-002
9603, -1.064331e-001, 1.263291e-001, 2.206639e-002
9604, -1.048303e-001, 1.174524e-001, 2.206628e-002
9605, -1.046522e-001, 1.164661e-001, 2.206627e-002
9606, -1.044739e-001, 1.154798e-001, 2.206629e-002
9607, -1.042959e-001, 1.144935e-001, 2.206626e-002
9608, -1.041176e-001, 1.135072e-001, 2.206628e-002
9609, -1.039392e-001, 1.125210e-001, 2.206631e-002
9610, -1.037609e-001, 1.115347e-001, 2.206634e-002
9611, -1.035826e-001, 1.105484e-001, 2.206635e-002
9612, -1.034044e-001, 1.095622e-001, 2.206636e-002
9613, -1.032262e-001, 1.085759e-001, 2.206637e-002
9614, -1.030480e-001, 1.075896e-001, 2.206637e-002
9615, -1.028698e-001, 1.066033e-001, 2.206637e-002
9616, -1.026916e-001, 1.056170e-001, 2.206637e-002
9617, -1.025135e-001, 1.046307e-001, 2.206637e-002
9618, -1.023353e-001, 1.036445e-001, 2.206637e-002
9619, -1.021571e-001, 1.026582e-001, 2.206637e-002
9620, -1.019790e-001, 1.016719e-001, 2.206637e-002
9621, -1.018008e-001, 1.006856e-001, 2.206637e-002
9622, -1.016226e-001, 9.969932e-002, 2.206637e-002
9623, -1.014444e-001, 9.871304e-002, 2.206637e-002
9624, -1.012663e-001, 9.772676e-002, 2.206637e-002
9625, -1.010881e-001, 9.674047e-002, 2.206637e-002
9626, -1.009099e-001, 9.575419e-002, 2.206637e-002
9627, -1.007317e-001, 9.476790e-002, 2.206637e-002
9628, -1.005536e-001, 9.378162e-002, 2.206637e-002
9629, -1.003754e-001, 9.279533e-002, 2.206637e-002
9630, -1.001972e-001, 9.180905e-002, 2.206637e-002
9631, -1.000191e-001, 9.082277e-002, 2.206637e-002
9632, -9.984088e-002, 8.983648e-002, 2.206637e-002
9633, -9.966271e-002, 8.885020e-002, 2.206637e-002
9634, -9.948454e-002, 8.786391e-002, 2.206637e-002
9635, -9.930636e-002, 8.687763e-002, 2.206637e-002
9636, -9.912819e-002, 8.589135e-002, 2.206637e-002
9637, -9.895002e-002, 8.490506e-002, 2.206637e-002
9638, -9.877184e-002, 8.391878e-002, 2.206637e-002
9639, -9.859367e-002, 8.293249e-002, 2.206637e-002
9640, -9.841550e-002, 8.194621e-002, 2.206637e-002
9641, -9.823733e-002, 8.095993e-002, 2.206637e-002
9642, -9.805915e-002, 7.997364e-002, 2.206637e-002
9643, -9.788098e-002, 7.898736e-002, 2.206637e-002
9644, -9.770281e-002, 7.800107e-002, 2.206637e-002
9645, -9.752464e-002, 7.701479e-002, 2.206637e-002
9646, -9.734646e-002, 7.602850e-002, 2.206637e-002
9647, -9.716829e-002, 7.504222e-002, 2.206637e-002
9648, -9.699012e-002, 7.405594e-002, 2.206637e-002
9649, -9.681195e-002, 7.306965e-002, 2.206637e-002
9650, -9.663377e-002, 7.208337e-002, 2.206637e-002
9651, -9.645560e-002, 7.109708e-002, 2.206637e-002
9652, -9.627743e-002, 7.011080e-002, 2.206637e-002
9653, -9.609926e-002, 6.912452e-002, 2.206637e-002
9654, -9.592108e-002, 6.813823e-002, 2.206637e-002
9655, -9.574291e-002, 6.715195e-002, 2.206637e-002
9656, -9.556474e-002, 6.616566e-002, 2.206637e-002
9657, -9.538657e-002, 6.517938e-002, 2.206637e-002
9658, -9.520839e-002, 6.419309e-002, 2.206637e-002
9659, -9.503022e-002, 6.320681e-002, 2.206637e-002
9660, -9.485205e-002, 6.222053e-002, 2.206637e-002
9661, -9.467388e-002, 6.123424e-002, 2.206637e-002
9662, -9.449570e-002, 6.024796e-002, 2.206637e-002
9663, -9.431753e-002, 5.926167e-002, 2.206637e-002
9664, -9.413936e-002, 5.827539e-002, 2.206637e-002
9665, -9.396119e-002, 5.728911e-002, 2.206637e-002
9666, -9.378301e-002, 5.630282e-002, 2.206637e-002
9667, -9.360484e-002, 5.531654e-002, 2.206637e-002
9668, -9.342667e-002, 5.433025e-002, 2.206637e-002
9669, -9.324850e-002, 5.334397e-002, 2.206637e-002
9670, -9.307032e-002, 5.235768e-002, 2.206637e-002
9671, -9.289215e-002, 5.137140e-002, 2.206637e-002
9672, -9.271398e-002, 5.038512e-002, 2.206637e-002
9673, -9.253580e-002, 4.939883e-002, 2.206637e-002
9674, -9.235763e-002, 4.841255e-002, 2.206637e-002
9675, -9.217946e-002, 4.742626e-002, 2.206637e-002
9676, -9.200129e-002, 4.643998e-002, 2.206637e-002
9677, -9.182311e-002, 4.545370e-002, 2.206637e-002
9678, -9.164494e-002, 4.446741e-002, 2.206637e-002
9679, -9.146677e-002, 4.348113e-002, 2.206637e-002
9680, -9.128860e-002, 4.249484e-002, 2.206637e-002
9681, -9.111042e-002, 4.150856e-002, 2.206637e-002
9682, -9.093225e-002, 4.052227e-002, 2.206637e-002
9683, -9.075408e-002, 3.953599e-002, 2.206637e-002
9684, -9.057591e-002, 3.854971e-002, 2.206637e-002
9685, -9.039773e-002, 3.756342e-002, 2.206637e-002
9686, -9.021956e-002, 3.657714e-002, 2.206637e-002
9687, -9.004139e-002, 3.559085e-002, 2.206637e-002
9688, -8.986322e-002, 3.460457e-002, 2.206637e-002
9689, -8.968504e-002, 3.361829e-002, 2.206637e-002
9690, -8.950687e-002, 3.263200e-002, 2.206637e-002
9691, -8.932870e-002, 3.164572e-002, 2.206637e-002
9692, -8.915041e-002, 3.065944e-002, 2.206639e-002
9693, -8.897133e-002, 2.967319e-002, 2.206652e-002
9694, -8.879023e-002, 2.868693e-002, 2.206696e-002
9695, -8.860616e-002, 2.770047e-002, 2.206783e-002
9696, -8.841912e-002, 2.671358e-002, 2.206914e-002
9697, -8.823007e-002, 2.572622e-002, 2.207076e-002
9698, -1.103525e-001, 1.480274e-001, 2.206645e-002
9699, -1.069679e-001, 1.292879e-001, 2.206635e-002
9700, -1.071451e-001, 1.302744e-001, 2.206651e-002
9701, -1.101732e-001, 1.470413e-001, 2.206662e-002
9702, -1.057200e-001, 1.223840e-001, 2.206646e-002
9703, -1.136496e-001, 1.555927e-001, 2.208548e-002
9704, -1.134775e-001, 1.545999e-001, 2.208670e-002
9705, -1.133061e-001, 1.536088e-001, 2.208798e-002
9706, -1.131345e-001, 1.526191e-001, 2.208922e-002
9707, -1.129622e-001, 1.516307e-001, 2.209029e-002
9708, -1.127884e-001, 1.506431e-001, 2.209109e-002
9709, -1.126128e-001, 1.496561e-001, 2.209156e-002
9710, -1.124358e-001, 1.486695e-001, 2.209178e-002
9711, -1.122574e-001, 1.476833e-001, 2.209173e-002
9712, -1.120789e-001, 1.466970e-001, 2.209167e-002
9713, -1.119011e-001, 1.457107e-001, 2.209175e-002
9714, -1.117234e-001, 1.447243e-001, 2.209183e-002
9715, -1.115453e-001, 1.437380e-001, 2.209184e-002
9716, -1.113667e-001, 1.427518e-001, 2.209176e-002
9717, -1.111882e-001, 1.417656e-001, 2.209171e-002
9718, -1.110103e-001, 1.407792e-001, 2.209176e-002
9719, -1.108323e-001, 1.397929e-001, 2.209180e-002
9720, -1.106538e-001, 1.388067e-001, 2.209174e-002
9721, -1.104756e-001, 1.378204e-001, 2.209172e-002
9722, -1.102975e-001, 1.368341e-001, 2.209173e-002
9723, -1.101196e-001, 1.358478e-001, 2.209179e-002
9724, -1.099419e-001, 1.348614e-001, 2.209187e-002
9725, -1.097640e-001, 1.338751e-001, 2.209192e-002
9726, -1.095854e-001, 1.328889e-001, 2.209184e-002
9727, -1.094068e-001, 1.319027e-001, 2.209177e-002
9728, -1.092281e-001, 1.309165e-001, 2.209166e-002
9729, -1.090501e-001, 1.299302e-001, 2.209171e-002
9730, -1.088725e-001, 1.289438e-001, 2.209180e-002
9731, -1.086948e-001, 1.279574e-001, 2.209189e-002
9732, -1.085168e-001, 1.269711e-001, 2.209193e-002
9733, -1.083383e-001, 1.259849e-001, 2.209185e-002
9734, -1.081601e-001, 1.249986e-001, 2.209185e-002
9735, -1.079815e-001, 1.240124e-001, 2.209177e-002
9736, -1.078029e-001, 1.230262e-001, 2.209170e-002
9737, -1.076251e-001, 1.220398e-001, 2.209177e-002
9738, -1.074473e-001, 1.210535e-001, 2.209183e-002
9739, -1.072689e-001, 1.200672e-001, 2.209180e-002
9740, -1.070906e-001, 1.190810e-001, 2.209177e-002
9741, -1.069125e-001, 1.180947e-001, 2.209180e-002
9742, -1.067346e-001, 1.171083e-001, 2.209184e-002
9743, -1.065567e-001, 1.161220e-001, 2.209189e-002
9744, -1.063784e-001, 1.151357e-001, 2.209187e-002
9745, -1.062005e-001, 1.141494e-001, 2.209192e-002
9746, -1.060222e-001, 1.131631e-001, 2.209188e-002
9747, -1.058438e-001, 1.121769e-001, 2.209185e-002
9748, -1.056655e-001, 1.111906e-001, 2.209182e-002
9749, -1.054872e-001, 1.102043e-001, 2.209180e-002
9750, -1.053090e-001, 1.092181e-001, 2.209179e-002
9751, -1.051308e-001, 1.082318e-001, 2.209179e-002
9752, -1.049526e-001, 1.072455e-001, 2.209178e-002
9753, -1.047744e-001, 1.062592e-001, 2.209178e-002
9754, -1.045962e-001, 1.052729e-001, 2.209178e-002
9755, -1.044181e-001, 1.042867e-001, 2.209178e-002
9756, -1.042399e-001, 1.033004e-001, 2.209178e-002
9757, -1.040617e-001, 1.023141e-001, 2.209178e-002
9758, -1.038835e-001, 1.013278e-001, 2.209178e-002
9759, -1.037054e-001, 1.003415e-001, 2.209178e-002
9760, -1.035272e-001, 9.935524e-002, 2.209178e-002
9761, -1.033490e-001, 9.836895e-002, 2.209178e-002
9762, -1.031708e-001, 9.738267e-002, 2.209178e-002
9763, -1.029927e-001, 9.639639e-002, 2.209178e-002
9764, -1.028145e-001, 9.541010e-002, 2.209178e-002
9765, -1.026363e-001, 9.442382e-002, 2.209178e-002
9766, -1.024582e-001, 9.343753e-002, 2.209178e-002
9767, -1.022800e-001, 9.245125e-002, 2.209178e-002
9768, -1.021018e-001, 9.146497e-002, 2.209178e-002
9769, -1.019236e-001, 9.047868e-002, 2.209178e-002
9770, -1.017455e-001, 8.949240e-002, 2.209178e-002
9771, -1.015673e-001, 8.850611e-002, 2.209178e-002
9772, -1.013891e-001, 8.751983e-002, 2.209178e-002
9773, -1.012109e-001, 8.653354e-002, 2.209178e-002
9774, -1.010328e-001, 8.554726e-002, 2.209178e-002
9775, -1.008546e-001, 8.456098e-002, 2.209178e-002
9776, -1.006764e-001, 8.357469e-002, 2.209178e-002
9777, -1.004983e-001, 8.258841e-002, 2.209178e-002
9778, -1.003201e-001, 8.160212e-002, 2.209178e-002
9779, -1.001419e-001, 8.061584e-002, 2.209178e-002
9780, -9.996374e-002, 7.962956e-002, 2.209178e-002
9781, -9.978557e-002, 7.864327e-002, 2.209178e-002
9782, -9.960739e-002, 7.765699e-002, 2.209178e-002
