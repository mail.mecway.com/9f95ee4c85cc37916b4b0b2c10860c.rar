1972, -8.627181e-002, -1.854163e-002, 1.696652e-002
1973, -8.665825e-002, -1.905422e-002, 1.772135e-002
1974, -8.689133e-002, -1.957239e-002, 1.853294e-002
1975, -8.696478e-002, -2.008209e-002, 1.937919e-002
1976, -8.687663e-002, -2.056948e-002, 2.023712e-002
1977, -8.662924e-002, -2.102131e-002, 2.108339e-002
1978, -8.622931e-002, -2.142524e-002, 2.189494e-002
1979, -8.568774e-002, -2.177022e-002, 2.264961e-002
1980, -8.501928e-002, -2.204682e-002, 2.332680e-002
1981, -8.424218e-002, -2.224744e-002, 2.390803e-002
1982, -8.337763e-002, -2.236660e-002, 2.437744e-002
1983, -8.244922e-002, -2.240109e-002, 2.472220e-002
1984, -8.148228e-002, -2.234998e-002, 2.493289e-002
1985, -8.050317e-002, -2.221467e-002, 2.500376e-002
1986, -8.416353e-002, -2.278790e-002, 1.267510e-002
1987, -8.431886e-002, -2.192238e-002, 1.318188e-002
1988, -8.447278e-002, -2.105603e-002, 1.368760e-002
1989, -8.462507e-002, -2.018874e-002, 1.419207e-002
1990, -8.493004e-002, -1.845445e-002, 1.520133e-002
1991, -8.385111e-002, -2.451813e-002, 1.166013e-002
1992, -8.400743e-002, -2.365302e-002, 1.216772e-002
1993, -8.369423e-002, -2.538346e-002, 1.115189e-002
1994, -8.353580e-002, -2.624921e-002, 1.064194e-002
1995, -8.337527e-002, -2.711381e-002, 1.013037e-002
1996, -8.321556e-002, -2.797176e-002, 9.622346e-003
1997, -8.305286e-002, -2.884769e-002, 9.104023e-003
1998, -8.324807e-002, -2.993093e-002, 8.885848e-003
1999, -7.628241e-002, -2.684766e-002, 9.246807e-003
2000, -7.561705e-002, -2.742482e-002, 9.331273e-003
2001, -7.501446e-002, -2.815039e-002, 9.363255e-003
2002, -7.783074e-002, -1.627782e-002, 1.570699e-002
2003, -8.477699e-002, -1.932125e-002, 1.469628e-002
2004, -7.261092e-002, -3.330884e-002, 9.163785e-003
2005, -7.231682e-002, -3.436200e-002, 9.052427e-003
2006, -7.206398e-002, -3.539974e-002, 8.927748e-003
2007, -7.184573e-002, -3.642386e-002, 8.792351e-003
2008, -7.165742e-002, -3.743574e-002, 8.648885e-003
2009, -7.149601e-002, -3.843568e-002, 8.499792e-003
2010, -7.135953e-002, -3.942398e-002, 8.347776e-003
2011, -7.124705e-002, -4.039990e-002, 8.195647e-003
2012, -7.115855e-002, -4.136162e-002, 8.046574e-003
2013, -7.109490e-002, -4.230559e-002, 7.904372e-003
2014, -7.105791e-002, -4.322559e-002, 7.773903e-003
2015, -7.104991e-002, -4.411179e-002, 7.660412e-003
2016, -7.107087e-002, -4.495245e-002, 7.563994e-003
2017, -7.111314e-002, -4.573991e-002, 7.472052e-003
2018, -7.116144e-002, -4.647448e-002, 7.363945e-003
2019, -7.120078e-002, -4.716273e-002, 7.225048e-003
2020, -7.120740e-002, -4.778271e-002, 7.039797e-003
2021, -7.156242e-002, -4.799940e-002, 7.439457e-003
2022, -7.197848e-002, -4.832511e-002, 7.776791e-003
2023, -7.245575e-002, -4.861673e-002, 8.090973e-003
2024, -7.304111e-002, -4.879564e-002, 8.441582e-003
2025, -7.383516e-002, -4.915829e-002, 8.702234e-003
2026, -7.469087e-002, -4.944769e-002, 8.860006e-003
2027, -7.559431e-002, -4.965837e-002, 8.907463e-003
2028, -7.651162e-002, -4.978447e-002, 8.838450e-003
2029, -7.740203e-002, -4.982241e-002, 8.660158e-003
2030, -7.822652e-002, -4.977577e-002, 8.393528e-003
2031, -7.895474e-002, -4.966149e-002, 8.066064e-003
2032, -7.957063e-002, -4.951449e-002, 7.698999e-003
2033, -8.006429e-002, -4.938613e-002, 7.305133e-003
2034, -8.040083e-002, -4.932229e-002, 6.943586e-003
2035, -8.062089e-002, -4.892617e-002, 6.967245e-003
2036, -8.088681e-002, -4.848318e-002, 6.936346e-003
2037, -8.113047e-002, -4.795422e-002, 6.986114e-003
2038, -8.138465e-002, -4.734560e-002, 7.057951e-003
2039, -8.164948e-002, -4.665740e-002, 7.144501e-003
2040, -8.191694e-002, -4.589987e-002, 7.245602e-003
2041, -8.217964e-002, -4.508617e-002, 7.360474e-003
2042, -8.243232e-002, -4.422843e-002, 7.487678e-003
2043, -8.267177e-002, -4.333625e-002, 7.624892e-003
2044, -8.289612e-002, -4.241658e-002, 7.769192e-003
2045, -8.310404e-002, -4.147412e-002, 7.917504e-003
2046, -8.329427e-002, -4.051177e-002, 8.066881e-003
2047, -8.346531e-002, -3.953101e-002, 8.214570e-003
2048, -8.361514e-002, -3.853213e-002, 8.357954e-003
2049, -8.374098e-002, -3.751437e-002, 8.494419e-003
2050, -8.383889e-002, -3.647572e-002, 8.621122e-003
2051, -8.390299e-002, -3.541271e-002, 8.734484e-003
2052, -8.392411e-002, -3.432136e-002, 8.829362e-003
2053, -8.388870e-002, -3.320141e-002, 8.900344e-003
2054, -8.378077e-002, -3.205621e-002, 8.947496e-003
2055, -8.356531e-002, -3.083867e-002, 8.969089e-003
2056, -7.767450e-002, -1.714270e-002, 1.519957e-002
2057, -7.751826e-002, -1.800758e-002, 1.469214e-002
2058, -7.736201e-002, -1.887246e-002, 1.418472e-002
2059, -7.720577e-002, -1.973734e-002, 1.367731e-002
2060, -7.704953e-002, -2.060222e-002, 1.316988e-002
2061, -7.689327e-002, -2.146713e-002, 1.266246e-002
2062, -7.673664e-002, -2.233235e-002, 1.215509e-002
2063, -7.657765e-002, -2.319926e-002, 1.164835e-002
2064, -7.641251e-002, -2.406920e-002, 1.114422e-002
2065, -7.625641e-002, -2.493659e-002, 1.063486e-002
2066, -7.611910e-002, -2.579599e-002, 1.011661e-002
2067, -7.586931e-002, -2.648199e-002, 9.815225e-003
2068, -7.953860e-002, -2.199887e-002, 2.493288e-002
2069, -7.861489e-002, -2.170844e-002, 2.472218e-002
2070, -7.775723e-002, -2.135131e-002, 2.437742e-002
2071, -7.698902e-002, -2.093719e-002, 2.390801e-002
2072, -7.633122e-002, -2.047734e-002, 2.332678e-002
2073, -7.580178e-002, -1.998433e-002, 2.264957e-002
2074, -7.541513e-002, -1.947162e-002, 2.189484e-002
2075, -7.518181e-002, -1.895321e-002, 2.108318e-002
2076, -7.510818e-002, -1.844326e-002, 2.023670e-002
2077, -7.519626e-002, -1.795570e-002, 1.937850e-002
2078, -7.544364e-002, -1.750382e-002, 1.853198e-002
2079, -7.584358e-002, -1.709992e-002, 1.772025e-002
2080, -7.638516e-002, -1.675499e-002, 1.696547e-002
2081, -7.705363e-002, -1.647844e-002, 1.628823e-002
2082, -7.441922e-002, -2.904630e-002, 9.370882e-003
2083, -7.386037e-002, -3.007152e-002, 9.356300e-003
2084, -7.337183e-002, -3.114919e-002, 9.318703e-003
2085, -7.296049e-002, -3.223328e-002, 9.250343e-003
2086, -7.740440e-002, -2.773506e-002, 8.117416e-003
2087, -8.558781e-002, -1.891468e-002, 1.578333e-002
2088, -8.611685e-002, -1.940777e-002, 1.646114e-002
2089, -8.650280e-002, -1.992015e-002, 1.721596e-002
2090, -8.673543e-002, -2.043798e-002, 1.802724e-002
2091, -8.680858e-002, -2.094733e-002, 1.887306e-002
2092, -8.672030e-002, -2.143445e-002, 1.973058e-002
2093, -8.647290e-002, -2.188608e-002, 2.057653e-002
2094, -8.607303e-002, -2.228990e-002, 2.138786e-002
2095, -8.553150e-002, -2.263485e-002, 2.214241e-002
2096, -8.486307e-002, -2.291144e-002, 2.281955e-002
2097, -8.408598e-002, -2.311203e-002, 2.340078e-002
2098, -8.322144e-002, -2.323116e-002, 2.387021e-002
2099, -8.229304e-002, -2.326564e-002, 2.421497e-002
2100, -8.132610e-002, -2.321453e-002, 2.442566e-002
2101, -8.034699e-002, -2.307923e-002, 2.449653e-002
2102, -8.482207e-002, -2.325161e-002, 1.326270e-002
2103, -8.497658e-002, -2.238506e-002, 1.376836e-002
2104, -8.419464e-002, -2.671153e-002, 1.122955e-002
2105, -8.435240e-002, -2.584843e-002, 1.173841e-002
2106, -8.403982e-002, -2.755694e-002, 1.073072e-002
2107, -7.456034e-002, -2.785899e-002, 1.017167e-002
2108, -7.402025e-002, -2.882147e-002, 1.021044e-002
2109, -8.450964e-002, -2.498323e-002, 1.224728e-002
2110, -8.389377e-002, -2.836116e-002, 1.025786e-002
2111, -8.377173e-002, -2.913226e-002, 9.828783e-003
2112, -8.375394e-002, -2.987797e-002, 9.554249e-003
2113, -7.307914e-002, -3.105805e-002, 1.024789e-002
2114, -7.272444e-002, -3.221014e-002, 1.020766e-002
2115, -8.466609e-002, -2.411741e-002, 1.275532e-002
2116, -7.689739e-002, -1.734332e-002, 1.578081e-002
2117, -7.243692e-002, -3.333709e-002, 1.013481e-002
2118, -7.220236e-002, -3.443459e-002, 1.003477e-002
2119, -7.200931e-002, -3.550613e-002, 9.914393e-003
2120, -7.185005e-002, -3.655647e-002, 9.778756e-003
2121, -7.171970e-002, -3.758848e-002, 9.631453e-003
2122, -7.161519e-002, -3.860173e-002, 9.475059e-003
2123, -7.153452e-002, -3.959803e-002, 9.313004e-003
2124, -7.147683e-002, -4.057653e-002, 9.148329e-003
2125, -7.144206e-002, -4.153527e-002, 8.984286e-003
2126, -7.143098e-002, -4.247004e-002, 8.824741e-003
2127, -7.144485e-002, -4.337355e-002, 8.674195e-003
2128, -7.148403e-002, -4.423610e-002, 8.535603e-003
2129, -7.154366e-002, -4.505067e-002, 8.403666e-003
2130, -7.160862e-002, -4.581848e-002, 8.259217e-003
2131, -7.165951e-002, -4.654327e-002, 8.083211e-003
2132, -7.170881e-002, -4.725045e-002, 7.892408e-003
2133, -7.215896e-002, -4.781041e-002, 8.165774e-003
2134, -7.253118e-002, -4.807280e-002, 8.391125e-003
2135, -7.330328e-002, -4.795947e-002, 9.003225e-003
2136, -7.403914e-002, -4.832857e-002, 9.213263e-003
2137, -7.486972e-002, -4.861767e-002, 9.354722e-003
2138, -7.575540e-002, -4.882576e-002, 9.396937e-003
2139, -7.665288e-002, -4.894984e-002, 9.328915e-003
2140, -7.752019e-002, -4.899094e-002, 9.156425e-003
2141, -7.832154e-002, -4.895799e-002, 8.897163e-003
2142, -7.903620e-002, -4.887295e-002, 8.568583e-003
2143, -7.966621e-002, -4.877153e-002, 8.168755e-003
2144, -8.024475e-002, -4.868527e-002, 7.655034e-003
2145, -8.064181e-002, -4.834364e-002, 7.429838e-003
2146, -8.078239e-002, -4.787532e-002, 7.625081e-003
2147, -8.101435e-002, -4.729136e-002, 7.777367e-003
2148, -8.128358e-002, -4.662530e-002, 7.922270e-003
2149, -8.157074e-002, -4.589334e-002, 8.065181e-003
2150, -8.186403e-002, -4.510686e-002, 8.207814e-003
2151, -8.215374e-002, -4.427580e-002, 8.354137e-003
2152, -8.243435e-002, -4.340777e-002, 8.505562e-003
2153, -8.270300e-002, -4.250863e-002, 8.660949e-003
2154, -8.295795e-002, -4.158260e-002, 8.817881e-003
2155, -8.319782e-002, -4.063238e-002, 8.973545e-003
2156, -8.342108e-002, -3.965926e-002, 9.125068e-003
2157, -8.362581e-002, -3.866324e-002, 9.269556e-003
2158, -8.380934e-002, -3.764293e-002, 9.403958e-003
2159, -8.396792e-002, -3.659536e-002, 9.524783e-003
2160, -8.409580e-002, -3.551598e-002, 9.627608e-003
2161, -8.418419e-002, -3.440207e-002, 9.707765e-003
2162, -8.422275e-002, -3.326292e-002, 9.767462e-003
2163, -8.421007e-002, -3.213292e-002, 9.827485e-003
2164, -8.417821e-002, -3.106855e-002, 9.946971e-003
2165, -8.512984e-002, -2.151765e-002, 1.427262e-002
2166, -8.528218e-002, -2.064968e-002, 1.477587e-002
2167, -8.543452e-002, -1.978180e-002, 1.527909e-002
2168, -7.674115e-002, -1.820819e-002, 1.527339e-002
2169, -7.658491e-002, -1.907304e-002, 1.476599e-002
2170, -7.642868e-002, -1.993790e-002, 1.425858e-002
2171, -7.627243e-002, -2.080278e-002, 1.375115e-002
2172, -7.611617e-002, -2.166772e-002, 1.324372e-002
2173, -7.595951e-002, -2.253308e-002, 1.273639e-002
2174, -7.579967e-002, -2.340094e-002, 1.223068e-002
2175, -7.563036e-002, -2.427067e-002, 1.173429e-002
2176, -7.545813e-002, -2.512772e-002, 1.125142e-002
2177, -7.529995e-002, -2.597275e-002, 1.076201e-002
2178, -7.513310e-002, -2.690719e-002, 1.021152e-002
2179, -7.938242e-002, -2.286344e-002, 2.442564e-002
2180, -7.845870e-002, -2.257304e-002, 2.421493e-002
2181, -7.760103e-002, -2.221594e-002, 2.387014e-002
2182, -7.683282e-002, -2.180186e-002, 2.340071e-002
2183, -7.617503e-002, -2.134198e-002, 2.281950e-002
2184, -7.564559e-002, -2.084890e-002, 2.214233e-002
2185, -7.525895e-002, -2.033613e-002, 2.138763e-002
2186, -7.502563e-002, -1.981771e-002, 2.057598e-002
2187, -7.495200e-002, -1.930781e-002, 1.972947e-002
2188, -7.504007e-002, -1.882033e-002, 1.887123e-002
2189, -7.528743e-002, -1.836853e-002, 1.802466e-002
2190, -7.568735e-002, -1.796469e-002, 1.721289e-002
2191, -7.622893e-002, -1.761983e-002, 1.645807e-002
2192, -7.351377e-002, -2.991181e-002, 1.024207e-002
2193, -8.421780e-002, -3.018478e-002, 1.022786e-002
2194, -8.596288e-002, -2.027487e-002, 1.595734e-002
2195, -8.634790e-002, -2.078687e-002, 1.671198e-002
2196, -8.657974e-002, -2.130419e-002, 1.752269e-002
2197, -8.665239e-002, -2.181305e-002, 1.836786e-002
2198, -8.656386e-002, -2.229972e-002, 1.922473e-002
2199, -8.631642e-002, -2.275098e-002, 2.007013e-002
2200, -8.591664e-002, -2.315453e-002, 2.088107e-002
2201, -8.537523e-002, -2.349931e-002, 2.163542e-002
2202, -8.470688e-002, -2.377581e-002, 2.231248e-002
2203, -8.392982e-002, -2.397639e-002, 2.289369e-002
2204, -8.306528e-002, -2.409556e-002, 2.336308e-002
2205, -8.213688e-002, -2.413009e-002, 2.370781e-002
2206, -8.116993e-002, -2.407901e-002, 2.391847e-002
2207, -8.019081e-002, -2.394373e-002, 2.398933e-002
2208, -8.534886e-002, -2.374717e-002, 1.394475e-002
2209, -8.550287e-002, -2.287916e-002, 1.444880e-002
2210, -7.260721e-002, -3.222510e-002, 1.119013e-002
2211, -7.238878e-002, -3.340109e-002, 1.112378e-002
2212, -8.457125e-002, -2.801767e-002, 1.142784e-002
2213, -8.472317e-002, -2.719725e-002, 1.191608e-002
2214, -7.409691e-002, -2.783879e-002, 1.098471e-002
2215, -7.369677e-002, -2.866657e-002, 1.108165e-002
2216, -8.429911e-002, -2.947854e-002, 1.055552e-002
2217, -7.325795e-002, -2.980060e-002, 1.116821e-002
2218, -7.289319e-002, -3.101254e-002, 1.120209e-002
2219, -7.607270e-002, -1.848465e-002, 1.595069e-002
2220, -8.519316e-002, -2.461437e-002, 1.343776e-002
2221, -7.216819e-002, -4.729245e-002, 8.385847e-003
2222, -7.222068e-002, -3.453876e-002, 1.102542e-002
2223, -7.209173e-002, -3.563867e-002, 1.089973e-002
2224, -7.192304e-002, -3.775915e-002, 1.059537e-002
2225, -7.187514e-002, -3.877953e-002, 1.042284e-002
2226, -7.184902e-002, -3.977926e-002, 1.024261e-002
2227, -7.184382e-002, -4.075558e-002, 1.005774e-002
2228, -7.185957e-002, -4.170697e-002, 9.871649e-003
2229, -7.189686e-002, -4.262804e-002, 9.688467e-003
2230, -7.195605e-002, -4.351076e-002, 9.512211e-003
2231, -7.203526e-002, -4.434935e-002, 9.343184e-003
2232, -7.212452e-002, -4.514856e-002, 9.169111e-003
2233, -7.219577e-002, -4.592713e-002, 8.955867e-003
2234, -7.219633e-002, -4.665359e-002, 8.671002e-003
2235, -7.269997e-002, -4.754609e-002, 8.760736e-003
2236, -7.347845e-002, -4.721538e-002, 9.465065e-003
2237, -7.422104e-002, -4.754002e-002, 9.693191e-003
2238, -7.504183e-002, -4.780571e-002, 9.837775e-003
2239, -7.591202e-002, -4.799896e-002, 9.882679e-003
2240, -7.679228e-002, -4.811829e-002, 9.817658e-003
2241, -7.764448e-002, -4.816786e-002, 9.645605e-003
2242, -7.843647e-002, -4.815681e-002, 9.380378e-003
2243, -7.915161e-002, -4.810070e-002, 9.037092e-003
2244, -7.978546e-002, -4.803339e-002, 8.614013e-003
2245, -8.033920e-002, -4.796916e-002, 8.115118e-003
2246, -8.054766e-002, -4.730038e-002, 8.405782e-003
2247, -8.580956e-002, -2.114273e-002, 1.545457e-002
2248, -8.081204e-002, -4.660816e-002, 8.639853e-003
2249, -8.110992e-002, -4.587526e-002, 8.846820e-003
2250, -8.143312e-002, -4.510135e-002, 9.025664e-003
2251, -8.175893e-002, -4.429106e-002, 9.196410e-003
2252, -8.207885e-002, -4.344589e-002, 9.367433e-003
2253, -8.238973e-002, -4.256825e-002, 9.539850e-003
2254, -8.268996e-002, -4.166087e-002, 9.711804e-003
2255, -8.297829e-002, -4.072573e-002, 9.880519e-003
2256, -8.325339e-002, -3.976371e-002, 1.004295e-002
2257, -8.351353e-002, -3.877434e-002, 1.019590e-002
2258, -8.375641e-002, -3.775558e-002, 1.033582e-002
2259, -8.397866e-002, -3.670340e-002, 1.045853e-002
2260, -8.417495e-002, -3.561239e-002, 1.055890e-002
2261, -8.433651e-002, -3.448111e-002, 1.063356e-002
2262, -8.445192e-002, -3.332907e-002, 1.068718e-002
2263, -8.451800e-002, -3.220940e-002, 1.074550e-002
2264, -8.454572e-002, -3.119631e-002, 1.082599e-002
2265, -8.565623e-002, -2.201083e-002, 1.495173e-002
2266, -8.503667e-002, -2.548128e-002, 1.292936e-002
2267, -8.442552e-002, -2.877073e-002, 1.096810e-002
2268, -7.591647e-002, -1.934945e-002, 1.544332e-002
2269, -7.576024e-002, -2.021429e-002, 1.493591e-002
2270, -7.560399e-002, -2.107921e-002, 1.442847e-002
2271, -7.544773e-002, -2.194418e-002, 1.392100e-002
2272, -7.529040e-002, -2.281018e-002, 1.341436e-002
2273, -7.512613e-002, -2.367818e-002, 1.291738e-002
2274, -7.494744e-002, -2.454012e-002, 1.244983e-002
2275, -7.475936e-002, -2.537903e-002, 1.201956e-002
2276, -7.457719e-002, -2.619128e-002, 1.160470e-002
2277, -7.922625e-002, -2.372791e-002, 2.391846e-002
2278, -7.830254e-002, -2.343747e-002, 2.370777e-002
2279, -7.744488e-002, -2.308032e-002, 2.336302e-002
2280, -7.667667e-002, -2.266618e-002, 2.289361e-002
2281, -7.601889e-002, -2.220623e-002, 2.231244e-002
2282, -7.548947e-002, -2.171308e-002, 2.163531e-002
2283, -7.510284e-002, -2.120030e-002, 2.088062e-002
2284, -7.486951e-002, -2.068196e-002, 2.006892e-002
2285, -7.479585e-002, -2.017220e-002, 1.922233e-002
2286, -7.488389e-002, -1.968486e-002, 1.836400e-002
2287, -7.513123e-002, -1.923318e-002, 1.751737e-002
2288, -7.553114e-002, -1.882942e-002, 1.670556e-002
2289, -8.487945e-002, -2.634432e-002, 1.242058e-002
2290, -7.199405e-002, -3.671016e-002, 1.075485e-002
2291, -8.453294e-002, -3.039398e-002, 1.086940e-002
2292, -7.281246e-002, -4.688076e-002, 9.144826e-003
2293, -8.619340e-002, -2.165439e-002, 1.620901e-002
2294, -8.642424e-002, -2.217127e-002, 1.701925e-002
2295, -8.649615e-002, -2.267960e-002, 1.786373e-002
2296, -8.640720e-002, -2.316566e-002, 1.871974e-002
2297, -8.615967e-002, -2.361633e-002, 1.956430e-002
2298, -8.576001e-002, -2.401941e-002, 2.037459e-002
2299, -8.521881e-002, -2.436387e-002, 2.112856e-002
2300, -8.455063e-002, -2.464019e-002, 2.180547e-002
2301, -8.377362e-002, -2.484079e-002, 2.238658e-002
2302, -8.290909e-002, -2.496007e-002, 2.285588e-002
2303, -8.198068e-002, -2.499467e-002, 2.320056e-002
2304, -8.101373e-002, -2.494364e-002, 2.341120e-002
2305, -8.003462e-002, -2.480834e-002, 2.348207e-002
2306, -8.573034e-002, -2.426054e-002, 1.470107e-002
2307, -8.588480e-002, -2.339137e-002, 1.520404e-002
2308, -7.537492e-002, -1.969418e-002, 1.619821e-002
2309, -7.310590e-002, -2.971924e-002, 1.211946e-002
2310, -7.281811e-002, -3.100892e-002, 1.218242e-002
2311, -7.261385e-002, -3.227310e-002, 1.217599e-002
2312, -8.603904e-002, -2.252256e-002, 1.570637e-002
2313, -7.350905e-002, -2.844601e-002, 1.193765e-002
2314, -8.510195e-002, -2.771808e-002, 1.266222e-002
2315, -8.526035e-002, -2.686367e-002, 1.317454e-002
2316, -8.541798e-002, -2.599784e-002, 1.368585e-002
2317, -7.227797e-002, -3.687941e-002, 1.170207e-002
2318, -7.226485e-002, -3.793204e-002, 1.151929e-002
2319, -7.237557e-002, -3.466799e-002, 1.200703e-002
2320, -7.231269e-002, -3.578750e-002, 1.186433e-002
2321, -7.247164e-002, -3.349303e-002, 1.211165e-002
2322, -7.229775e-002, -3.995617e-002, 1.111767e-002
2323, -7.234128e-002, -4.092431e-002, 1.090600e-002
2324, -7.240311e-002, -4.186242e-002, 1.069220e-002
2325, -7.248334e-002, -4.276051e-002, 1.048173e-002
2326, -7.258100e-002, -4.360979e-002, 1.027842e-002
2327, -7.269846e-002, -4.441709e-002, 1.008373e-002
2328, -7.282842e-002, -4.520796e-002, 9.880300e-003
2329, -7.295120e-002, -4.609148e-002, 9.604764e-003
2330, -7.366072e-002, -4.649002e-002, 9.921847e-003
2331, -7.439916e-002, -4.679103e-002, 1.015101e-002
2332, -8.557447e-002, -2.512918e-002, 1.419430e-002
2333, -7.520490e-002, -4.701981e-002, 1.030431e-002
2334, -7.606228e-002, -4.718556e-002, 1.036019e-002
2335, -7.693476e-002, -4.729770e-002, 1.029956e-002
2336, -7.778685e-002, -4.736169e-002, 1.011942e-002
2337, -7.858270e-002, -4.738568e-002, 9.829753e-003
2338, -7.931567e-002, -4.735329e-002, 9.456974e-003
2339, -7.998100e-002, -4.732239e-002, 8.972345e-003
2340, -8.022348e-002, -4.659508e-002, 9.297308e-003
2341, -8.050991e-002, -4.583393e-002, 9.598375e-003
2342, -8.088200e-002, -4.505496e-002, 9.806253e-003
2343, -8.124777e-002, -4.426159e-002, 1.000135e-002
2344, -8.160577e-002, -4.343945e-002, 1.019552e-002
2345, -8.195643e-002, -4.258497e-002, 1.038995e-002
2346, -8.229943e-002, -4.169880e-002, 1.058257e-002
2347, -8.263411e-002, -4.078189e-002, 1.077055e-002
2348, -8.295950e-002, -3.983456e-002, 1.095065e-002
2349, -8.327431e-002, -3.885588e-002, 1.111934e-002
2350, -8.357677e-002, -3.784312e-002, 1.127259e-002
2351, -8.386425e-002, -3.679125e-002, 1.140551e-002
2352, -8.413205e-002, -3.569369e-002, 1.151238e-002
2353, -8.437066e-002, -3.455132e-002, 1.158944e-002
2354, -8.456583e-002, -3.338878e-002, 1.164466e-002
2355, -8.471020e-002, -3.224904e-002, 1.170606e-002
2356, -8.480691e-002, -3.114931e-002, 1.177305e-002
2357, -8.478278e-002, -2.924844e-002, 1.165075e-002
2358, -8.494117e-002, -2.852916e-002, 1.214787e-002
2359, -7.521869e-002, -2.055902e-002, 1.569082e-002
2360, -7.506245e-002, -2.142393e-002, 1.518336e-002
2361, -7.490580e-002, -2.228959e-002, 1.467615e-002
2362, -7.474503e-002, -2.315887e-002, 1.417545e-002
2363, -7.457265e-002, -2.403225e-002, 1.369986e-002
2364, -7.438331e-002, -2.490465e-002, 1.327031e-002
2365, -7.417921e-002, -2.577963e-002, 1.288238e-002
2366, -7.401653e-002, -2.658522e-002, 1.245850e-002
2367, -7.907006e-002, -2.459248e-002, 2.341122e-002
2368, -7.814637e-002, -2.430191e-002, 2.320060e-002
2369, -7.728873e-002, -2.394456e-002, 2.285595e-002
2370, -7.652055e-002, -2.353017e-002, 2.238667e-002
2371, -7.586279e-002, -2.307001e-002, 2.180558e-002
2372, -7.533338e-002, -2.257674e-002, 2.112846e-002
2373, -7.494675e-002, -2.206395e-002, 2.037375e-002
2374, -7.471342e-002, -2.154586e-002, 1.956195e-002
2375, -7.463972e-002, -2.103642e-002, 1.871523e-002
2376, -7.472772e-002, -2.054935e-002, 1.785679e-002
2377, -7.497503e-002, -2.009784e-002, 1.701007e-002
2378, -7.436647e-002, -2.702568e-002, 1.122339e-002
2379, -7.384314e-002, -2.739114e-002, 1.206732e-002
2380, -7.227187e-002, -3.895604e-002, 1.132356e-002
2381, -8.480314e-002, -3.029269e-002, 1.165310e-002
2382, -8.626887e-002, -2.303932e-002, 1.651663e-002
2383, -8.633984e-002, -2.354715e-002, 1.736054e-002
2384, -8.625028e-002, -2.403248e-002, 1.821560e-002
2385, -8.600254e-002, -2.448240e-002, 1.905912e-002
2386, -8.560301e-002, -2.488487e-002, 1.986848e-002
2387, -8.506210e-002, -2.522893e-002, 2.062176e-002
2388, -8.439418e-002, -2.550507e-002, 2.129828e-002
2389, -8.361729e-002, -2.570565e-002, 2.187924e-002
2390, -8.275281e-002, -2.582495e-002, 2.234848e-002
2391, -8.182441e-002, -2.585960e-002, 2.269312e-002
2392, -8.085746e-002, -2.580860e-002, 2.290373e-002
2393, -7.987836e-002, -2.567332e-002, 2.297459e-002
2394, -8.595797e-002, -2.477788e-002, 1.551145e-002
2395, -8.611346e-002, -2.390818e-002, 1.601409e-002
2396, -7.305039e-002, -2.972033e-002, 1.310668e-002
2397, -7.286213e-002, -3.104707e-002, 1.317307e-002
2398, -7.279809e-002, -3.912309e-002, 1.215859e-002
2399, -7.287090e-002, -4.011132e-002, 1.192114e-002
2400, -8.532550e-002, -2.827529e-002, 1.345641e-002
2401, -8.548677e-002, -2.739631e-002, 1.398377e-002
2402, -7.269708e-002, -3.704458e-002, 1.259818e-002
2403, -7.273914e-002, -3.809807e-002, 1.238552e-002
2404, -7.332133e-002, -2.847250e-002, 1.293582e-002
2405, -7.481882e-002, -2.096258e-002, 1.650273e-002
2406, -8.515624e-002, -2.914296e-002, 1.288985e-002
2407, -7.364834e-002, -4.509038e-002, 1.057434e-002
2408, -7.390752e-002, -4.584622e-002, 1.037620e-002
2409, -7.268937e-002, -3.361253e-002, 1.308671e-002
2410, -7.266653e-002, -3.480662e-002, 1.295559e-002
2411, -7.295804e-002, -4.106550e-002, 1.167746e-002
2412, -7.305933e-002, -4.198142e-002, 1.143189e-002
2413, -7.267019e-002, -3.594328e-002, 1.278867e-002
2414, -7.317096e-002, -4.283740e-002, 1.119214e-002
2415, -7.328270e-002, -4.361912e-002, 1.095939e-002
2416, -7.344026e-002, -4.437354e-002, 1.075353e-002
2417, -7.456929e-002, -4.611105e-002, 1.056982e-002
2418, -7.534552e-002, -4.626549e-002, 1.074798e-002
2419, -7.620383e-002, -4.638440e-002, 1.082994e-002
2420, -7.950663e-002, -4.659699e-002, 9.865123e-003
2421, -7.966785e-002, -4.573167e-002, 1.036955e-002
2422, -7.708724e-002, -4.648166e-002, 1.077792e-002
2423, -7.796324e-002, -4.655495e-002, 1.058483e-002
2424, -7.876030e-002, -4.664950e-002, 1.024180e-002
2425, -8.580180e-002, -2.564824e-002, 1.500577e-002
2426, -7.362219e-002, -2.714327e-002, 1.327992e-002
2427, -7.357147e-002, -2.765347e-002, 1.275711e-002
2428, -8.023053e-002, -4.493644e-002, 1.052692e-002
2429, -8.063256e-002, -4.417006e-002, 1.074716e-002
2430, -8.102185e-002, -4.337457e-002, 1.097147e-002
2431, -8.140789e-002, -4.254599e-002, 1.119357e-002
2432, -8.179009e-002, -4.168454e-002, 1.141183e-002
2433, -8.216789e-002, -4.078964e-002, 1.162459e-002
2434, -8.254082e-002, -3.986103e-002, 1.182861e-002
2435, -8.290816e-002, -3.889736e-002, 1.202010e-002
2436, -8.326889e-002, -3.789539e-002, 1.219456e-002
2437, -8.362134e-002, -3.684929e-002, 1.234641e-002
2438, -8.396163e-002, -3.575224e-002, 1.246889e-002
2439, -8.427896e-002, -3.460801e-002, 1.255744e-002
2440, -8.455571e-002, -3.344103e-002, 1.262313e-002
2441, -8.478446e-002, -3.226236e-002, 1.270089e-002
2442, -8.500149e-002, -3.085417e-002, 1.285568e-002
2443, -8.497848e-002, -2.986892e-002, 1.226510e-002
2444, -7.466251e-002, -2.182762e-002, 1.599538e-002
2445, -7.450477e-002, -2.269510e-002, 1.549096e-002
2446, -7.434189e-002, -2.356745e-002, 1.500257e-002
2447, -7.416792e-002, -2.444760e-002, 1.455461e-002
2448, -7.397262e-002, -2.535807e-002, 1.417258e-002
2449, -7.371577e-002, -2.644859e-002, 1.389314e-002
2450, -7.891379e-002, -2.545738e-002, 2.290378e-002
2451, -7.799004e-002, -2.516660e-002, 2.269323e-002
2452, -8.564495e-002, -2.652039e-002, 1.449739e-002
2453, -7.713234e-002, -2.480890e-002, 2.234867e-002
2454, -7.636416e-002, -2.439399e-002, 2.187954e-002
2455, -7.570634e-002, -2.393313e-002, 2.129849e-002
2456, -7.274793e-002, -3.234965e-002, 1.315893e-002
2457, -7.517683e-002, -2.343916e-002, 2.062110e-002
2458, -7.479052e-002, -2.292585e-002, 1.986664e-002
2459, -7.455740e-002, -2.240832e-002, 1.905496e-002
2460, -7.448368e-002, -2.190001e-002, 1.820813e-002
2461, -7.457158e-002, -2.141371e-002, 1.734953e-002
2462, -8.618342e-002, -2.441566e-002, 1.685779e-002
2463, -8.609310e-002, -2.490018e-002, 1.771225e-002
2464, -8.584500e-002, -2.534911e-002, 1.855485e-002
2465, -8.544554e-002, -2.575080e-002, 1.936301e-002
2466, -8.490499e-002, -2.609452e-002, 2.011514e-002
2467, -8.423744e-002, -2.637052e-002, 2.079097e-002
2468, -8.346077e-002, -2.657104e-002, 2.137167e-002
2469, -8.259637e-002, -2.669042e-002, 2.184076e-002
2470, -8.166799e-002, -2.672527e-002, 2.218524e-002
2471, -8.070103e-002, -2.667450e-002, 2.239571e-002
2472, -7.972188e-002, -2.653929e-002, 2.246653e-002
2473, -8.602686e-002, -2.528511e-002, 1.635506e-002
2474, -7.875716e-002, -2.632314e-002, 2.239577e-002
2475, -7.896400e-002, -4.597939e-002, 1.059677e-002
2476, -7.934546e-002, -4.530102e-002, 1.086338e-002
2477, -7.332005e-002, -2.822628e-002, 1.392508e-002
2478, -7.311809e-002, -2.975442e-002, 1.411070e-002
2479, -7.633579e-002, -4.557084e-002, 1.130588e-002
2480, -7.725183e-002, -4.564763e-002, 1.126611e-002
2481, -7.467998e-002, -4.553087e-002, 1.091265e-002
2482, -7.542352e-002, -4.551033e-002, 1.117578e-002
2483, -7.324302e-002, -3.719501e-002, 1.342606e-002
2484, -7.333615e-002, -3.824447e-002, 1.317667e-002
2485, -7.344102e-002, -3.925833e-002, 1.291268e-002
2486, -7.347321e-002, -2.737896e-002, 1.438323e-002
2487, -7.963807e-002, -4.472970e-002, 1.109050e-002
2488, -7.441530e-002, -2.227857e-002, 1.684280e-002
2489, -7.380705e-002, -4.204567e-002, 1.207792e-002
2490, -7.393188e-002, -4.287015e-002, 1.179641e-002
2491, -7.303416e-002, -3.111491e-002, 1.416094e-002
2492, -7.355464e-002, -4.022868e-002, 1.263927e-002
2493, -7.395519e-002, -4.355282e-002, 1.149579e-002
2494, -7.413975e-002, -4.430123e-002, 1.125558e-002
2495, -7.822596e-002, -4.564036e-002, 1.109497e-002
2496, -8.519084e-002, -2.993360e-002, 1.368519e-002
2497, -8.538661e-002, -2.884700e-002, 1.431417e-002
2498, -8.571264e-002, -2.703069e-002, 1.534748e-002
2499, -8.587006e-002, -2.615594e-002, 1.585162e-002
2500, -7.304087e-002, -3.373919e-002, 1.402104e-002
2501, -7.309125e-002, -3.495036e-002, 1.385631e-002
2502, -7.301411e-002, -3.244862e-002, 1.412366e-002
2503, -8.033468e-002, -4.323787e-002, 1.168090e-002
2504, -8.075182e-002, -4.243565e-002, 1.193645e-002
2505, -8.116991e-002, -4.160409e-002, 1.218286e-002
2506, -8.158687e-002, -4.073638e-002, 1.242432e-002
2507, -8.200376e-002, -3.983119e-002, 1.265725e-002
2508, -8.242027e-002, -3.888686e-002, 1.287808e-002
2509, -8.283639e-002, -3.790063e-002, 1.308121e-002
2510, -8.325137e-002, -3.686678e-002, 1.326051e-002
2511, -8.366229e-002, -3.577892e-002, 1.340810e-002
2512, -8.405665e-002, -3.464457e-002, 1.351828e-002
2513, -8.441068e-002, -3.349694e-002, 1.360119e-002
2514, -8.470532e-002, -3.238471e-002, 1.367997e-002
2515, -8.493464e-002, -3.136353e-002, 1.378291e-002
2516, -7.993485e-002, -4.401664e-002, 1.140393e-002
2517, -7.425855e-002, -2.314355e-002, 1.634206e-002
2518, -7.410108e-002, -2.400502e-002, 1.586262e-002
2519, -7.394295e-002, -2.485727e-002, 1.542688e-002
2520, -7.378646e-002, -2.568955e-002, 1.505402e-002
2521, -7.364040e-002, -2.646500e-002, 1.477137e-002
2522, -7.783297e-002, -2.603209e-002, 2.218510e-002
2523, -8.555306e-002, -2.791895e-002, 1.483981e-002
2524, -7.697467e-002, -2.567385e-002, 2.184019e-002
2525, -7.620593e-002, -2.525750e-002, 2.137071e-002
2526, -7.554726e-002, -2.479411e-002, 2.078861e-002
2527, -7.501752e-002, -2.429621e-002, 2.010999e-002
2528, -7.463358e-002, -2.378008e-002, 1.935840e-002
2529, -7.440183e-002, -2.326514e-002, 1.854866e-002
2530, -7.432803e-002, -2.276143e-002, 1.770227e-002
2531, -7.315893e-002, -3.609426e-002, 1.365407e-002
2532, -7.367647e-002, -4.115533e-002, 1.236078e-002
2533, -8.463226e-002, -2.986103e-002, 1.118968e-002
2534, -8.593570e-002, -2.576846e-002, 1.720989e-002
2535, -8.568715e-002, -2.621575e-002, 1.805202e-002
2536, -8.528774e-002, -2.661653e-002, 1.885858e-002
2537, -8.474747e-002, -2.696055e-002, 1.960879e-002
2538, -8.408024e-002, -2.723676e-002, 2.028355e-002
2539, -8.330375e-002, -2.743742e-002, 2.086376e-002
2540, -8.243957e-002, -2.755745e-002, 2.133216e-002
2541, -8.151145e-002, -2.759333e-002, 2.167588e-002
2542, -8.054457e-002, -2.754346e-002, 2.188586e-002
2543, -7.956514e-002, -2.740859e-002, 2.195654e-002
2544, -7.859895e-002, -2.719286e-002, 2.188519e-002
2545, -7.884286e-002, -4.519740e-002, 1.117077e-002
2546, -7.648790e-002, -4.472390e-002, 1.180269e-002
2547, -7.736336e-002, -4.485627e-002, 1.173290e-002
2548, -8.482030e-002, -3.135244e-002, 1.474594e-002
2549, -8.509577e-002, -3.026567e-002, 1.485903e-002
2550, -7.896083e-002, -4.385300e-002, 1.200834e-002
2551, -7.949227e-002, -4.303273e-002, 1.232748e-002
2552, -7.537696e-002, -2.564783e-002, 2.026612e-002
2553, -7.484870e-002, -2.513373e-002, 1.958608e-002
2554, -7.447388e-002, -4.118583e-002, 1.294374e-002
2555, -7.462369e-002, -4.205874e-002, 1.261645e-002
2556, -8.529056e-002, -2.928841e-002, 1.525522e-002
2557, -8.545880e-002, -2.838695e-002, 1.572220e-002
2558, -7.444000e-002, -4.489078e-002, 1.112761e-002
2559, -7.347157e-002, -2.772926e-002, 1.520412e-002
2560, -7.337181e-002, -2.866299e-002, 1.510655e-002
2561, -7.889343e-002, -4.465854e-002, 1.150564e-002
2562, -7.482667e-002, -4.297215e-002, 1.227270e-002
2563, -7.533751e-002, -4.454837e-002, 1.166434e-002
2564, -7.364324e-002, -3.508551e-002, 1.468997e-002
2565, -7.376925e-002, -3.622646e-002, 1.444293e-002
2566, -7.418575e-002, -3.934542e-002, 1.357554e-002
2567, -7.432764e-002, -4.028390e-002, 1.326299e-002
2568, -7.452585e-002, -4.388287e-002, 1.167078e-002
2569, -7.815442e-002, -4.486045e-002, 1.160754e-002
2570, -7.390226e-002, -3.731241e-002, 1.417063e-002
2571, -7.404020e-002, -3.834629e-002, 1.388070e-002
2572, -8.577810e-002, -2.663715e-002, 1.670902e-002
2573, -7.417359e-002, -2.361794e-002, 1.720363e-002
2574, -7.998140e-002, -4.224684e-002, 1.260850e-002
2575, -7.333985e-002, -3.119901e-002, 1.512841e-002
2576, -7.341337e-002, -3.255385e-002, 1.504990e-002
2577, -8.044461e-002, -4.144408e-002, 1.288360e-002
2578, -8.089958e-002, -4.060717e-002, 1.315659e-002
2579, -8.135906e-002, -3.972972e-002, 1.342118e-002
2580, -8.182094e-002, -3.880836e-002, 1.367734e-002
2581, -8.228919e-002, -3.784267e-002, 1.391502e-002
2582, -8.276213e-002, -3.682888e-002, 1.412870e-002
2583, -8.323888e-002, -3.575890e-002, 1.431093e-002
2584, -8.370632e-002, -3.464170e-002, 1.445432e-002
2585, -8.413540e-002, -3.351598e-002, 1.456393e-002
2586, -8.450423e-002, -3.242242e-002, 1.465799e-002
2587, -7.402274e-002, -2.446007e-002, 1.672694e-002
2588, -7.387772e-002, -2.528265e-002, 1.629039e-002
2589, -7.373995e-002, -2.608439e-002, 1.590227e-002
2590, -7.361611e-002, -2.679331e-002, 1.553133e-002
2591, -7.767226e-002, -2.690262e-002, 2.167266e-002
2592, -7.681070e-002, -2.654456e-002, 2.132455e-002
2593, -7.603748e-002, -2.612264e-002, 2.085109e-002
2594, -7.332064e-002, -2.988878e-002, 1.512797e-002
2595, -7.447617e-002, -2.460913e-002, 1.885127e-002
2596, -7.424868e-002, -2.410591e-002, 1.804958e-002
2597, -7.351979e-002, -3.385846e-002, 1.489688e-002
2598, -8.561960e-002, -2.750855e-002, 1.621146e-002
2599, -7.354067e-002, -2.701145e-002, 1.477051e-002
2600, -7.353485e-002, -2.717418e-002, 1.516596e-002
2601, -8.552910e-002, -2.708137e-002, 1.755139e-002
2602, -8.512974e-002, -2.748162e-002, 1.835531e-002
2603, -8.458889e-002, -2.782924e-002, 1.910183e-002
2604, -8.392148e-002, -2.810634e-002, 1.977527e-002
2605, -8.314517e-002, -2.830690e-002, 2.035482e-002
2606, -8.228318e-002, -2.842816e-002, 2.082086e-002
2607, -8.135723e-002, -2.846711e-002, 2.116218e-002
2608, -8.039073e-002, -2.842036e-002, 2.137098e-002
2609, -7.940796e-002, -2.828850e-002, 2.144048e-002
2610, -7.843602e-002, -2.807630e-002, 2.136591e-002
2611, -7.688412e-002, -4.393733e-002, 1.228182e-002
2612, -7.756647e-002, -4.418073e-002, 1.212238e-002
2613, -7.362409e-002, -2.878454e-002, 1.611941e-002
2614, -7.366202e-002, -2.995626e-002, 1.609779e-002
2615, -7.817649e-002, -4.424344e-002, 1.198981e-002
2616, -7.583780e-002, -2.700269e-002, 2.029405e-002
2617, -7.517265e-002, -2.648337e-002, 1.970304e-002
2618, -7.448362e-002, -3.631596e-002, 1.514107e-002
2619, -7.465613e-002, -3.737544e-002, 1.482212e-002
2620, -8.505065e-002, -2.964458e-002, 1.611273e-002
2621, -8.521045e-002, -2.880585e-002, 1.657011e-002
2622, -7.962353e-002, -4.120345e-002, 1.348954e-002
2623, -8.011031e-002, -4.039479e-002, 1.380576e-002
2624, -7.366502e-002, -2.755081e-002, 1.619832e-002
2625, -7.544926e-002, -4.194205e-002, 1.306675e-002
2626, -7.565506e-002, -4.270323e-002, 1.274185e-002
2627, -8.537018e-002, -2.794652e-002, 1.705516e-002
2628, -7.501709e-002, -3.937203e-002, 1.413985e-002
2629, -7.516955e-002, -4.028111e-002, 1.378035e-002
2630, -7.800398e-002, -4.310953e-002, 1.272247e-002
2631, -7.858797e-002, -4.259948e-002, 1.292804e-002
2632, -7.430604e-002, -3.518568e-002, 1.543862e-002
2633, -7.605500e-002, -4.345925e-002, 1.244222e-002
2634, -8.061708e-002, -3.953801e-002, 1.411155e-002
2635, -7.532317e-002, -4.112859e-002, 1.343007e-002
2636, -7.483412e-002, -3.838845e-002, 1.448956e-002
2637, -8.457943e-002, -3.136670e-002, 1.566325e-002
2638, -8.487683e-002, -3.046148e-002, 1.573865e-002
2639, -7.911812e-002, -4.193987e-002, 1.319740e-002
2640, -7.377137e-002, -3.125386e-002, 1.604777e-002
2641, -7.393633e-002, -3.263669e-002, 1.591535e-002
2642, -7.411855e-002, -3.395828e-002, 1.570120e-002
2643, -7.410163e-002, -2.492109e-002, 1.757228e-002
2644, -8.418190e-002, -3.241037e-002, 1.560121e-002
2645, -8.112126e-002, -3.863160e-002, 1.441667e-002
2646, -8.164474e-002, -3.769315e-002, 1.468806e-002
2647, -8.216990e-002, -3.671262e-002, 1.493737e-002
2648, -8.270372e-002, -3.567196e-002, 1.516132e-002
2649, -8.323695e-002, -3.458191e-002, 1.534623e-002
2650, -8.373598e-002, -3.348730e-002, 1.548852e-002
2651, -7.396513e-002, -2.571074e-002, 1.713715e-002
2652, -7.383381e-002, -2.658655e-002, 1.674129e-002
2653, -7.750211e-002, -2.779360e-002, 2.114538e-002
2654, -7.662793e-002, -2.744215e-002, 2.078304e-002
2655, -7.465760e-002, -2.591919e-002, 1.903185e-002
2656, -7.432403e-002, -2.537581e-002, 1.836400e-002
2657, -7.774243e-002, -4.374424e-002, 1.236857e-002
2658, -8.497068e-002, -2.834744e-002, 1.785386e-002
2659, -8.442652e-002, -2.870982e-002, 1.859056e-002
2660, -8.375931e-002, -2.898549e-002, 1.926326e-002
2661, -8.298498e-002, -2.918081e-002, 1.984391e-002
2662, -8.213418e-002, -2.930314e-002, 2.030285e-002
2663, -8.121535e-002, -2.935175e-002, 2.063797e-002
2664, -8.024514e-002, -2.931557e-002, 2.084432e-002
2665, -7.925261e-002, -2.919051e-002, 2.091205e-002
2666, -7.827220e-002, -2.898803e-002, 2.083126e-002
2667, -7.678371e-002, -4.298204e-002, 1.282285e-002
2668, -7.737138e-002, -4.342133e-002, 1.258797e-002
2669, -7.527626e-002, -3.634194e-002, 1.573853e-002
2670, -7.548038e-002, -3.737630e-002, 1.536970e-002
2671, -7.643279e-002, -2.841283e-002, 2.019913e-002
2672, -7.553888e-002, -2.795033e-002, 1.960603e-002
2673, -7.637314e-002, -4.246144e-002, 1.305576e-002
2674, -7.420677e-002, -2.796280e-002, 1.767104e-002
2675, -7.401330e-002, -2.900553e-002, 1.704885e-002
2676, -7.921309e-002, -4.009190e-002, 1.435448e-002
2677, -7.979301e-002, -3.924391e-002, 1.471265e-002
2678, -7.627101e-002, -4.183508e-002, 1.337776e-002
2679, -7.594235e-002, -3.935251e-002, 1.459579e-002
2680, -7.606040e-002, -4.024598e-002, 1.417101e-002
2681, -7.505871e-002, -3.522880e-002, 1.609299e-002
2682, -7.419308e-002, -2.602427e-002, 1.794506e-002
2683, -7.442304e-002, -2.659346e-002, 1.841034e-002
2684, -7.456802e-002, -3.267728e-002, 1.670590e-002
2685, -7.481665e-002, -3.401471e-002, 1.641646e-002
2686, -7.777103e-002, -4.219117e-002, 1.330163e-002
2687, -7.823316e-002, -4.159311e-002, 1.361823e-002
2688, -7.627693e-002, -4.104101e-002, 1.380998e-002
2689, -7.490997e-002, -2.728754e-002, 1.906437e-002
2690, -7.871817e-002, -4.087810e-002, 1.397819e-002
2691, -8.427066e-002, -3.126428e-002, 1.653262e-002
2692, -8.462862e-002, -3.058431e-002, 1.638289e-002
2693, -8.466963e-002, -3.003320e-002, 1.685622e-002
2694, -7.430902e-002, -3.124752e-002, 1.690380e-002
2695, -8.481128e-002, -2.921090e-002, 1.735567e-002
2696, -8.032090e-002, -3.832378e-002, 1.510053e-002
2697, -8.093428e-002, -3.742051e-002, 1.539316e-002
2698, -8.150538e-002, -3.648699e-002, 1.567730e-002
2699, -8.207549e-002, -3.549590e-002, 1.594790e-002
2700, -8.265762e-002, -3.445003e-002, 1.618258e-002
2701, -8.321916e-002, -3.339290e-002, 1.636764e-002
2702, -7.570075e-002, -3.836881e-002, 1.499371e-002
2703, -7.413643e-002, -2.696367e-002, 1.769306e-002
2704, -7.732917e-002, -2.873201e-002, 2.059312e-002
2705, -8.373799e-002, -3.232176e-002, 1.652940e-002
2706, -7.411393e-002, -2.995229e-002, 1.700240e-002
2707, -8.425402e-002, -2.963072e-002, 1.806024e-002
2708, -8.359562e-002, -2.987636e-002, 1.874369e-002
2709, -8.282598e-002, -3.004536e-002, 1.933888e-002
2710, -8.201128e-002, -3.017576e-002, 1.977284e-002
2711, -8.110347e-002, -3.025580e-002, 2.009224e-002
2712, -8.011962e-002, -3.024051e-002, 2.029771e-002
2713, -7.911124e-002, -3.011956e-002, 2.036958e-002
2714, -7.813180e-002, -2.992111e-002, 2.029200e-002
2715, -7.734965e-002, -4.266469e-002, 1.303403e-002
2716, -7.510614e-002, -2.827923e-002, 1.898616e-002
2717, -7.691972e-002, -4.234555e-002, 1.319826e-002
2718, -7.460505e-002, -2.980967e-002, 1.779719e-002
2719, -7.492683e-002, -3.117963e-002, 1.768085e-002
2720, -7.468046e-002, -2.876427e-002, 1.825195e-002
2721, -8.402077e-002, -3.076611e-002, 1.743930e-002
2722, -7.721254e-002, -2.971296e-002, 2.004728e-002
2723, -7.588920e-002, -3.522154e-002, 1.664483e-002
2724, -7.611366e-002, -3.630383e-002, 1.622386e-002
2725, -7.633862e-002, -3.730671e-002, 1.580623e-002
2726, -7.559647e-002, -3.402535e-002, 1.703181e-002
2727, -7.529260e-002, -3.267108e-002, 1.740974e-002
2728, -7.689492e-002, -4.019510e-002, 1.440568e-002
2729, -7.732851e-002, -4.127404e-002, 1.384255e-002
2730, -7.706502e-002, -4.189573e-002, 1.346773e-002
2731, -7.558651e-002, -2.896810e-002, 1.924352e-002
2732, -7.777468e-002, -4.052712e-002, 1.428804e-002
2733, -7.660717e-002, -3.826528e-002, 1.539152e-002
2734, -7.894794e-002, -3.885558e-002, 1.519050e-002
2735, -7.935367e-002, -3.780314e-002, 1.576530e-002
2736, -8.023054e-002, -3.702794e-002, 1.599860e-002
2737, -8.079542e-002, -3.617315e-002, 1.632126e-002
2738, -8.135690e-002, -3.523696e-002, 1.665746e-002
2739, -8.195415e-002, -3.423914e-002, 1.696496e-002
2740, -8.256871e-002, -3.323121e-002, 1.720165e-002
2741, -7.813886e-002, -3.967802e-002, 1.478076e-002
2742, -7.633299e-002, -2.960182e-002, 1.958380e-002
2743, -7.708704e-002, -3.930867e-002, 1.493108e-002
2744, -8.313084e-002, -3.210142e-002, 1.750785e-002
2745, -8.342811e-002, -3.075378e-002, 1.823903e-002
2746, -8.265663e-002, -3.083958e-002, 1.889294e-002
2747, -8.195111e-002, -3.102016e-002, 1.922779e-002
2748, -8.105407e-002, -3.119062e-002, 1.950590e-002
2749, -8.002966e-002, -3.120713e-002, 1.972150e-002
2750, -7.898639e-002, -3.106680e-002, 1.981808e-002
2751, -7.801433e-002, -3.081556e-002, 1.977972e-002
2752, -7.518850e-002, -2.981303e-002, 1.849843e-002
2753, -7.561993e-002, -3.102292e-002, 1.840144e-002
2754, -7.697758e-002, -3.625352e-002, 1.657384e-002
2755, -7.719813e-002, -3.717832e-002, 1.612905e-002
2756, -8.180746e-002, -3.300415e-002, 1.793879e-002
2757, -8.286313e-002, -3.136920e-002, 1.833185e-002
2758, -7.513426e-002, -2.893728e-002, 1.877597e-002
2759, -7.719231e-002, -3.055180e-002, 1.961670e-002
2760, -7.679743e-002, -3.515805e-002, 1.709307e-002
2761, -7.768261e-002, -3.874662e-002, 1.531901e-002
2762, -7.614529e-002, -3.263704e-002, 1.803844e-002
2763, -7.645320e-002, -3.400790e-002, 1.753541e-002
2764, -7.830173e-002, -3.785938e-002, 1.585274e-002
2765, -7.972614e-002, -3.655705e-002, 1.646162e-002
2766, -7.742436e-002, -3.802515e-002, 1.570036e-002
2767, -7.648167e-002, -3.049817e-002, 1.926263e-002
2768, -7.830916e-002, -3.849993e-002, 1.547372e-002
2769, -8.003999e-002, -3.582354e-002, 1.684282e-002
2770, -8.052874e-002, -3.492402e-002, 1.726366e-002
2771, -8.108979e-002, -3.392545e-002, 1.769288e-002
2772, -8.208989e-002, -3.174988e-002, 1.863987e-002
2773, -8.113309e-002, -3.220868e-002, 1.881362e-002
2774, -7.998250e-002, -3.225466e-002, 1.908847e-002
2775, -7.884445e-002, -3.205580e-002, 1.924092e-002
2776, -7.780832e-002, -3.168056e-002, 1.925811e-002
2777, -7.790951e-002, -3.499799e-002, 1.746712e-002
2778, -7.784254e-002, -3.623813e-002, 1.676169e-002
2779, -7.653745e-002, -3.132110e-002, 1.890143e-002
2780, -7.995799e-002, -3.335958e-002, 1.841193e-002
2781, -7.806861e-002, -3.701049e-002, 1.634229e-002
2782, -7.716473e-002, -3.119347e-002, 1.927958e-002
2783, -7.724264e-002, -3.256733e-002, 1.860468e-002
2784, -7.736128e-002, -3.399628e-002, 1.789113e-002
2785, -7.910631e-002, -3.556492e-002, 1.717875e-002
2786, -7.956775e-002, -3.457779e-002, 1.772479e-002
2787, -7.592370e-002, -3.040403e-002, 1.891855e-002
2788, -7.866991e-002, -3.311569e-002, 1.862042e-002
2789, -7.860524e-002, -3.426084e-002, 1.795767e-002
2790, -7.571240e-002, -2.969096e-002, 1.905622e-002
2791, -7.891452e-002, -3.673175e-002, 1.649244e-002
2792, -8.234723e-002, -3.231392e-002, 1.806074e-002
2793, -8.459595e-002, 6.015969e-003, 3.390782e-002
2794, -8.364868e-002, 6.191923e-003, 3.366302e-002
2795, -8.275562e-002, 6.361144e-003, 3.326300e-002
2796, -8.194104e-002, 6.519013e-003, 3.271920e-002
2797, -8.122621e-002, 6.661411e-003, 3.204609e-002
2798, -8.062966e-002, 6.784664e-003, 3.126042e-002
2799, -8.016923e-002, 6.885104e-003, 3.038474e-002
2800, -7.985790e-002, 6.959892e-003, 2.944395e-002
2801, -7.970396e-002, 7.007008e-003, 2.846452e-002
2802, -7.971100e-002, 7.025266e-003, 2.747370e-002
2803, -7.987808e-002, 7.014301e-003, 2.649853e-002
2804, -8.019998e-002, 6.974539e-003, 2.556521e-002
2805, -8.066766e-002, 6.907133e-003, 2.469838e-002
2806, -8.126874e-002, 6.813870e-003, 2.392059e-002
2807, -8.198860e-002, 6.697014e-003, 2.325170e-002
2808, -8.280668e-002, 6.559874e-003, 2.271163e-002
2809, -8.369988e-002, 6.406324e-003, 2.231547e-002
2810, -8.464374e-002, 6.240580e-003, 2.207369e-002
2811, -8.561283e-002, 6.067115e-003, 2.199248e-002
2812, -8.658127e-002, 5.890562e-003, 2.207386e-002
2813, -8.752326e-002, 5.715625e-003, 2.231574e-002
2814, -8.841352e-002, 5.546991e-003, 2.271193e-002
2815, -8.922775e-002, 5.389253e-003, 2.325204e-002
2816, -8.994298e-002, 5.246857e-003, 2.392104e-002
2817, -9.053876e-002, 5.123897e-003, 2.469911e-002
2818, -9.100036e-002, 5.023426e-003, 2.556609e-002
2819, -9.131564e-002, 4.948085e-003, 2.649926e-002
2820, -9.147583e-002, 4.899938e-003, 2.747399e-002
2821, -9.147604e-002, 4.880385e-003, 2.846427e-002
2822, -9.131550e-002, 4.890091e-003, 2.944324e-002
2823, -9.099790e-002, 4.928925e-003, 3.038384e-002
2824, -9.053153e-002, 4.995908e-003, 3.125965e-002
2825, -8.992949e-002, 5.089171e-003, 3.204563e-002
2826, -8.920989e-002, 5.205899e-003, 3.271897e-002
2827, -8.839146e-002, 5.343029e-003, 3.326290e-002
2828, -8.749559e-002, 5.496980e-003, 3.366297e-002
2829, -8.654659e-002, 5.663585e-003, 3.390781e-002
2830, -8.441501e-002, 5.026014e-003, 3.387819e-002
2831, -8.423481e-002, 4.036704e-003, 3.382916e-002
2832, -8.405522e-002, 3.048441e-003, 3.376070e-002
2833, -8.387610e-002, 2.061631e-003, 3.367282e-002
2834, -8.369741e-002, 1.076666e-003, 3.356551e-002
2835, -8.351937e-002, 9.388447e-005, 3.343886e-002
2836, -8.334204e-002, -8.863468e-004, 3.329291e-002
2837, -8.316534e-002, -1.863630e-003, 3.312768e-002
2838, -8.298931e-002, -2.837593e-003, 3.294324e-002
2839, -8.281401e-002, -3.807869e-003, 3.273964e-002
2840, -8.263948e-002, -4.774087e-003, 3.251698e-002
2841, -8.246575e-002, -5.735874e-003, 3.227531e-002
2842, -8.229289e-002, -6.692869e-003, 3.201474e-002
2843, -8.212095e-002, -7.644712e-003, 3.173535e-002
2844, -8.195002e-002, -8.591044e-003, 3.143727e-002
2845, -8.178015e-002, -9.531508e-003, 3.112059e-002
2846, -8.161140e-002, -1.046575e-002, 3.078545e-002
2847, -8.144383e-002, -1.139342e-002, 3.043195e-002
2848, -8.127752e-002, -1.231416e-002, 3.006025e-002
2849, -8.111257e-002, -1.322760e-002, 2.967050e-002
2850, -8.094917e-002, -1.413338e-002, 2.926289e-002
2851, -8.078753e-002, -1.503126e-002, 2.883758e-002
2852, -8.062779e-002, -1.592114e-002, 2.839464e-002
2853, -8.047017e-002, -1.680269e-002, 2.793427e-002
2854, -8.031517e-002, -1.767556e-002, 2.745677e-002
2855, -7.938763e-002, -1.738752e-002, 2.724216e-002
2856, -7.852731e-002, -1.703507e-002, 2.689165e-002
2857, -7.775750e-002, -1.662770e-002, 2.641539e-002
2858, -7.709788e-002, -1.617518e-002, 2.582577e-002
2859, -7.656717e-002, -1.569051e-002, 2.513885e-002
2860, -7.618024e-002, -1.518735e-002, 2.437373e-002
2861, -7.594769e-002, -1.468039e-002, 2.355162e-002
2862, -7.587547e-002, -1.418430e-002, 2.269518e-002
2863, -7.596494e-002, -1.371292e-002, 2.182806e-002
2864, -7.621300e-002, -1.327895e-002, 2.097396e-002
2865, -7.661233e-002, -1.289398e-002, 2.015588e-002
2866, -7.715184e-002, -1.256795e-002, 1.939563e-002
2867, -7.781738e-002, -1.230842e-002, 1.871362e-002
2868, -7.859260e-002, -1.211948e-002, 1.812911e-002
2869, -7.945559e-002, -1.200767e-002, 1.765841e-002
2870, -8.038177e-002, -1.197777e-002, 1.731371e-002
2871, -8.134565e-002, -1.203140e-002, 1.710357e-002
2872, -8.232126e-002, -1.216756e-002, 1.703308e-002
2873, -8.328260e-002, -1.238275e-002, 1.710395e-002
2874, -8.420412e-002, -1.267112e-002, 1.731455e-002
2875, -8.506107e-002, -1.302449e-002, 1.765991e-002
2876, -8.582995e-002, -1.343199e-002, 1.813151e-002
2877, -8.648895e-002, -1.387838e-002, 1.871717e-002
2878, -8.702069e-002, -1.435384e-002, 1.939985e-002
2879, -8.741118e-002, -1.484700e-002, 2.016080e-002
2880, -8.764984e-002, -1.534554e-002, 2.097958e-002
2881, -8.772983e-002, -1.583675e-002, 2.183421e-002
2882, -8.764831e-002, -1.630779e-002, 2.270166e-002
2883, -8.740672e-002, -1.674591e-002, 2.355829e-002
2884, -8.701098e-002, -1.713900e-002, 2.438037e-002
2885, -8.647171e-002, -1.747536e-002, 2.514508e-002
2886, -8.580428e-002, -1.774429e-002, 2.583121e-002
2887, -8.502858e-002, -1.793707e-002, 2.641967e-002
2888, -8.416505e-002, -1.805003e-002, 2.689479e-002
2889, -8.323609e-002, -1.808034e-002, 2.724405e-002
2890, -8.226681e-002, -1.802694e-002, 2.745758e-002
2891, -8.636919e-002, 4.672988e-003, 3.387827e-002
2892, -8.619096e-002, 3.683309e-003, 3.382938e-002
2893, -8.601254e-002, 2.694817e-003, 3.376108e-002
2894, -8.583426e-002, 1.707834e-003, 3.367333e-002
2895, -8.565630e-002, 7.227146e-004, 3.356615e-002
2896, -8.547874e-002, -2.601775e-004, 3.343958e-002
2897, -8.530165e-002, -1.240473e-003, 3.329366e-002
2898, -8.512511e-002, -2.217804e-003, 3.312846e-002
2899, -8.494917e-002, -3.191800e-003, 3.294402e-002
2900, -8.477390e-002, -4.162097e-003, 3.274043e-002
2901, -8.459937e-002, -5.128327e-003, 3.251775e-002
2902, -8.442563e-002, -6.090128e-003, 3.227607e-002
2903, -8.425277e-002, -7.047135e-003, 3.201549e-002
2904, -8.408083e-002, -7.998990e-003, 3.173610e-002
2905, -8.390989e-002, -8.945333e-003, 3.143801e-002
2906, -8.374001e-002, -9.885807e-003, 3.112132e-002
2907, -8.357125e-002, -1.082006e-002, 3.078616e-002
2908, -8.340366e-002, -1.174774e-002, 3.043266e-002
2909, -8.323740e-002, -1.266812e-002, 3.006110e-002
2910, -8.307254e-002, -1.358048e-002, 2.967182e-002
2911, -8.290906e-002, -1.448491e-002, 2.926481e-002
2912, -8.274695e-002, -1.538198e-002, 2.883982e-002
2913, -8.258612e-002, -1.627179e-002, 2.839673e-002
2914, -8.242627e-002, -1.715373e-002, 2.793582e-002
2915, -8.346703e-002, 5.206963e-003, 3.363261e-002
2916, -8.257482e-002, 5.383955e-003, 3.323180e-002
2917, -8.176250e-002, 5.552163e-003, 3.268761e-002
2918, -8.105041e-002, 5.707352e-003, 3.201416e-002
2919, -8.045624e-002, 5.845735e-003, 3.122687e-002
2920, -7.999890e-002, 5.962974e-003, 3.034897e-002
2921, -7.969176e-002, 6.055640e-003, 2.940617e-002
2922, -7.954293e-002, 6.121192e-003, 2.842572e-002
2923, -7.955546e-002, 6.157985e-003, 2.743529e-002
2924, -7.972769e-002, 6.165249e-003, 2.646203e-002
2925, -8.005380e-002, 6.143019e-003, 2.553170e-002
2926, -8.052446e-002, 6.092036e-003, 2.466823e-002
2927, -8.112763e-002, 6.013627e-003, 2.389326e-002
2928, -8.184995e-002, 5.909467e-003, 2.322567e-002
2929, -8.267008e-002, 5.782568e-003, 2.268664e-002
2930, -8.356424e-002, 5.636615e-003, 2.229159e-002
2931, -8.450778e-002, 5.475663e-003, 2.205073e-002
2932, -8.547546e-002, 5.304037e-003, 2.196992e-002
2933, -8.644187e-002, 5.126256e-003, 2.205103e-002
2934, -8.738170e-002, 4.946971e-003, 2.229209e-002
2935, -8.827001e-002, 4.770917e-003, 2.268721e-002
2936, -8.908247e-002, 4.602885e-003, 2.322632e-002
2937, -8.979553e-002, 4.447735e-003, 2.389411e-002
2938, -9.038813e-002, 4.310104e-003, 2.466961e-002
2939, -9.084671e-002, 4.193206e-003, 2.553335e-002
2940, -9.115961e-002, 4.100012e-003, 2.646339e-002
2941, -9.131812e-002, 4.033035e-003, 2.743585e-002
2942, -9.131697e-002, 3.994229e-003, 2.842526e-002
2943, -9.115491e-002, 3.984877e-003, 2.940487e-002
2944, -9.083514e-002, 4.005476e-003, 3.034733e-002
2945, -9.036585e-002, 4.055619e-003, 3.122552e-002
2946, -8.976057e-002, 4.133888e-003, 3.201348e-002
2947, -8.903878e-002, 4.237705e-003, 3.268744e-002
2948, -8.821859e-002, 4.364402e-003, 3.323188e-002
2949, -8.732068e-002, 4.510793e-003, 3.363272e-002
2950, -8.292812e-002, 2.257241e-003, 3.342672e-002
2951, -8.310698e-002, 3.239209e-003, 3.351454e-002
2952, -8.274929e-002, 1.277203e-003, 3.331945e-002
2953, -8.257139e-002, 2.992876e-004, 3.319306e-002
2954, -8.239457e-002, -6.761734e-004, 3.304764e-002
2955, -8.221841e-002, -1.648710e-003, 3.288307e-002
2956, -8.204307e-002, -2.617976e-003, 3.269944e-002
2957, -8.186859e-002, -3.583610e-003, 3.249681e-002
2958, -8.169494e-002, -4.545223e-003, 3.227523e-002
2959, -8.152205e-002, -5.502421e-003, 3.203472e-002
2960, -8.135001e-002, -6.454849e-003, 3.177540e-002
2961, -8.117891e-002, -7.402148e-003, 3.149735e-002
2962, -8.100881e-002, -8.343967e-003, 3.120070e-002
2963, -8.083977e-002, -9.279944e-003, 3.088555e-002
2964, -8.067185e-002, -1.020973e-002, 3.055202e-002
2965, -8.050511e-002, -1.113296e-002, 3.020022e-002
2966, -8.033964e-002, -1.204925e-002, 2.983034e-002
2967, -8.017567e-002, -1.295813e-002, 2.944262e-002
2968, -8.001351e-002, -1.385930e-002, 2.903733e-002
2969, -7.985337e-002, -1.475282e-002, 2.861454e-002
2970, -7.969532e-002, -1.563896e-002, 2.817416e-002
2971, -7.953973e-002, -1.651736e-002, 2.771647e-002
2972, -7.867746e-002, -1.616994e-002, 2.736133e-002
2973, -7.790630e-002, -1.576928e-002, 2.687958e-002
2974, -7.724517e-002, -1.532429e-002, 2.628336e-002
2975, -7.671328e-002, -1.484801e-002, 2.558911e-002
2976, -7.632551e-002, -1.435399e-002, 2.481579e-002
2977, -7.609271e-002, -1.385779e-002, 2.398524e-002
2978, -7.602054e-002, -1.337448e-002, 2.312036e-002
2979, -7.610999e-002, -1.291777e-002, 2.224532e-002
2980, -7.635747e-002, -1.250021e-002, 2.138393e-002
2981, -7.675526e-002, -1.213274e-002, 2.055918e-002
2982, -7.729223e-002, -1.182441e-002, 1.979270e-002
2983, -7.795487e-002, -1.158088e-002, 1.910497e-002
2984, -7.872854e-002, -1.140235e-002, 1.851654e-002
2985, -7.959059e-002, -1.129675e-002, 1.804390e-002
2986, -8.051552e-002, -1.127072e-002, 1.769856e-002
2987, -8.147759e-002, -1.132662e-002, 1.748841e-002
2988, -8.245109e-002, -1.146374e-002, 1.741803e-002
2989, -8.341052e-002, -1.167878e-002, 1.748899e-002
2990, -8.433084e-002, -1.196590e-002, 1.769987e-002
2991, -8.518764e-002, -1.231659e-002, 1.804626e-002
2992, -8.595737e-002, -1.271861e-002, 1.852052e-002
2993, -8.661787e-002, -1.315201e-002, 1.911167e-002
2994, -8.715192e-002, -1.360970e-002, 1.980120e-002
2995, -8.754577e-002, -1.408298e-002, 2.056969e-002
2996, -8.778884e-002, -1.456130e-002, 2.139653e-002
2997, -8.787391e-002, -1.503333e-002, 2.225979e-002
2998, -8.779751e-002, -1.548733e-002, 2.313637e-002
2999, -8.756014e-002, -1.591214e-002, 2.400189e-002
3000, -8.716716e-002, -1.629570e-002, 2.483214e-002
3001, -8.662922e-002, -1.662518e-002, 2.560396e-002
3002, -8.596233e-002, -1.688828e-002, 2.629598e-002
3003, -8.518786e-002, -1.707520e-002, 2.688884e-002
3004, -8.432555e-002, -1.718299e-002, 2.736770e-002
3005, -8.339679e-002, -1.720936e-002, 2.772020e-002
3006, -8.714364e-002, 3.525755e-003, 3.358385e-002
3007, -8.696611e-002, 2.541946e-003, 3.351583e-002
3008, -8.678864e-002, 1.559650e-003, 3.342851e-002
3009, -8.661148e-002, 5.792058e-004, 3.332185e-002
3010, -8.643474e-002, -3.990265e-004, 3.319589e-002
3011, -8.625850e-002, -1.374680e-003, 3.305066e-002
3012, -8.608280e-002, -2.347385e-003, 3.288623e-002
3013, -8.590772e-002, -3.316774e-003, 3.270266e-002
3014, -8.573330e-002, -4.282481e-003, 3.250002e-002
3015, -8.555961e-002, -5.244142e-003, 3.227838e-002
3016, -8.538672e-002, -6.201395e-003, 3.203784e-002
3017, -8.521469e-002, -7.153878e-003, 3.177848e-002
3018, -8.504359e-002, -8.101232e-003, 3.150040e-002
3019, -8.487348e-002, -9.043098e-003, 3.120370e-002
3020, -8.470444e-002, -9.979112e-003, 3.088851e-002
3021, -8.453641e-002, -1.090898e-002, 3.055494e-002
3022, -8.436938e-002, -1.183203e-002, 3.020328e-002
3023, -8.420423e-002, -1.274668e-002, 2.983403e-002
3024, -8.404067e-002, -1.365263e-002, 2.944751e-002
3025, -8.387837e-002, -1.455112e-002, 2.904328e-002
3026, -8.371722e-002, -1.544353e-002, 2.862059e-002
3027, -8.355702e-002, -1.632995e-002, 2.817934e-002
3028, -8.328643e-002, 4.222611e-003, 3.358311e-002
3029, -8.239540e-002, 4.407331e-003, 3.318202e-002
3030, -8.158542e-002, 4.585857e-003, 3.263801e-002
3031, -8.087625e-002, 4.753792e-003, 3.196508e-002
3032, -8.028475e-002, 4.907254e-003, 3.117762e-002
3033, -7.983046e-002, 5.041315e-003, 3.029910e-002
3034, -7.952703e-002, 5.151967e-003, 2.935570e-002
3035, -7.938251e-002, 5.236111e-003, 2.837518e-002
3036, -7.939959e-002, 5.291598e-003, 2.738557e-002
3037, -7.957612e-002, 5.317207e-003, 2.641404e-002
3038, -7.990588e-002, 5.312554e-003, 2.548610e-002
3039, -8.037938e-002, 5.277969e-003, 2.462515e-002
3040, -8.098479e-002, 5.214346e-003, 2.385222e-002
3041, -8.170953e-002, 5.122876e-003, 2.318563e-002
3042, -8.253174e-002, 5.006201e-003, 2.264736e-002
3043, -8.342719e-002, 4.867774e-003, 2.225308e-002
3044, -8.437101e-002, 4.711489e-003, 2.201285e-002
3045, -8.533809e-002, 4.541551e-003, 2.193233e-002
3046, -8.630329e-002, 4.362397e-003, 2.201327e-002
3047, -8.724163e-002, 4.178654e-003, 2.225377e-002
3048, -8.812836e-002, 3.995123e-003, 2.264815e-002
3049, -8.893912e-002, 3.816795e-003, 2.318652e-002
3050, -8.964995e-002, 3.648915e-003, 2.385336e-002
3051, -9.023953e-002, 3.496619e-003, 2.462702e-002
3052, -9.069497e-002, 3.363365e-003, 2.548836e-002
3053, -9.100501e-002, 3.252461e-003, 2.641592e-002
3054, -9.116102e-002, 3.166843e-003, 2.738637e-002
3055, -9.115759e-002, 3.108974e-003, 2.837463e-002
3056, -9.099313e-002, 3.080715e-003, 2.935407e-002
3057, -9.067061e-002, 3.083162e-003, 3.029712e-002
3058, -9.019821e-002, 3.116472e-003, 3.117617e-002
3059, -8.958983e-002, 3.179705e-003, 3.196468e-002
3060, -8.886582e-002, 3.270621e-003, 3.263843e-002
3061, -8.804381e-002, 3.386892e-003, 3.318273e-002
3062, -8.150690e-002, -4.521728e-004, 3.264738e-002
3063, -8.168265e-002, 5.155427e-004, 3.279195e-002
3064, -8.186012e-002, 1.485526e-003, 3.291813e-002
3065, -8.203819e-002, 2.457712e-003, 3.302526e-002
3066, -8.133143e-002, -1.416879e-003, 3.248362e-002
3067, -8.115710e-002, -2.378426e-003, 3.230118e-002
3068, -8.098398e-002, -3.336470e-003, 3.210013e-002
3069, -8.081182e-002, -4.290578e-003, 3.188037e-002
3070, -8.064024e-002, -5.240252e-003, 3.164173e-002
3071, -8.046954e-002, -6.185206e-003, 3.138444e-002
3072, -8.029974e-002, -7.125057e-003, 3.110856e-002
3073, -8.013100e-002, -8.059492e-003, 3.081426e-002
3074, -7.996330e-002, -8.988121e-003, 3.050160e-002
3075, -7.979671e-002, -9.910602e-003, 3.017070e-002
3076, -7.963132e-002, -1.082650e-002, 2.982173e-002
3077, -7.946732e-002, -1.173519e-002, 2.945499e-002
3078, -7.930506e-002, -1.263625e-002, 2.907087e-002
3079, -7.914486e-002, -1.352974e-002, 2.866960e-002
3080, -7.898679e-002, -1.441618e-002, 2.825104e-002
3081, -7.883072e-002, -1.529632e-002, 2.781477e-002
3082, -7.805802e-002, -1.490228e-002, 2.732793e-002
3083, -7.686290e-002, -1.399658e-002, 2.602607e-002
3084, -7.739507e-002, -1.446444e-002, 2.672543e-002
3085, -7.647432e-002, -1.351059e-002, 2.524639e-002
3086, -7.624118e-002, -1.302358e-002, 2.440996e-002
3087, -7.616866e-002, -1.255047e-002, 2.353894e-002
3088, -7.625756e-002, -1.210556e-002, 2.265814e-002
3089, -7.650391e-002, -1.170149e-002, 2.179092e-002
3090, -7.689984e-002, -1.134876e-002, 2.096036e-002
3091, -7.743434e-002, -1.105560e-002, 2.018800e-002
3092, -7.809452e-002, -1.082601e-002, 1.949458e-002
3093, -7.886684e-002, -1.065688e-002, 1.890196e-002
3094, -7.972811e-002, -1.055730e-002, 1.842676e-002
3095, -8.065218e-002, -1.053525e-002, 1.808002e-002
3096, -8.161312e-002, -1.059355e-002, 1.786926e-002
3097, -8.258537e-002, -1.073170e-002, 1.779880e-002
3098, -8.354371e-002, -1.094647e-002, 1.787005e-002
3099, -8.446346e-002, -1.123209e-002, 1.808170e-002
3100, -8.532040e-002, -1.157978e-002, 1.842966e-002
3101, -8.609106e-002, -1.197605e-002, 1.890697e-002
3102, -8.675344e-002, -1.239662e-002, 1.950404e-002
3103, -8.729007e-002, -1.283648e-002, 2.020111e-002
3104, -8.768722e-002, -1.328988e-002, 2.097775e-002
3105, -8.793426e-002, -1.374790e-002, 2.181307e-002
3106, -8.802372e-002, -1.420059e-002, 2.268509e-002
3107, -8.795127e-002, -1.463917e-002, 2.356972e-002
3108, -8.771667e-002, -1.505387e-002, 2.444206e-002
3109, -8.732505e-002, -1.543199e-002, 2.527740e-002
3110, -8.678764e-002, -1.575880e-002, 2.605254e-002
3111, -8.612095e-002, -1.601973e-002, 2.674729e-002
3112, -8.534732e-002, -1.620369e-002, 2.734234e-002
3113, -8.448599e-002, -1.630735e-002, 2.782396e-002
3114, -8.221635e-002, 3.431831e-003, 3.311308e-002
3115, -8.786748e-002, 2.410764e-003, 3.311530e-002
3116, -8.769123e-002, 1.436128e-003, 3.302875e-002
3117, -8.751533e-002, 4.633178e-004, 3.292299e-002
3118, -8.733991e-002, -5.073058e-004, 3.279804e-002
3119, -8.716502e-002, -1.475376e-003, 3.265395e-002
3120, -8.699070e-002, -2.440523e-003, 3.249079e-002
3121, -8.681699e-002, -3.402383e-003, 3.230863e-002
3122, -8.664394e-002, -4.360590e-003, 3.210754e-002
3123, -8.647163e-002, -5.314784e-003, 3.188761e-002
3124, -8.630011e-002, -6.264602e-003, 3.164892e-002
3125, -8.612944e-002, -7.209688e-003, 3.139155e-002
3126, -8.595970e-002, -8.149682e-003, 3.111561e-002
3127, -8.579096e-002, -9.084215e-003, 3.082119e-002
3128, -8.562315e-002, -1.001303e-002, 3.050844e-002
3129, -8.545553e-002, -1.093593e-002, 3.017781e-002
3130, -8.528847e-002, -1.185082e-002, 2.983008e-002
3131, -8.512617e-002, -1.275428e-002, 2.946498e-002
3132, -8.496561e-002, -1.364928e-002, 2.908275e-002
3133, -8.480554e-002, -1.453906e-002, 2.868231e-002
3134, -8.464600e-002, -1.542532e-002, 2.826251e-002
3135, -8.140857e-002, 3.620711e-003, 3.256938e-002
3136, -8.070235e-002, 3.801375e-003, 3.189728e-002
3137, -8.011389e-002, 3.969820e-003, 3.111054e-002
3138, -7.966291e-002, 4.120619e-003, 3.023268e-002
3139, -7.936310e-002, 4.249237e-003, 2.928993e-002
3140, -7.922250e-002, 4.352016e-003, 2.831026e-002
3141, -7.924361e-002, 4.426262e-003, 2.732196e-002
3142, -7.942399e-002, 4.470268e-003, 2.635225e-002
3143, -7.975714e-002, 4.483209e-003, 2.542644e-002
3144, -8.023347e-002, 4.464996e-003, 2.456758e-002
3145, -8.084127e-002, 4.416110e-003, 2.379636e-002
3146, -8.156837e-002, 4.337327e-003, 2.313079e-002
3147, -8.239261e-002, 4.230879e-003, 2.259332e-002
3148, -8.328944e-002, 4.099953e-003, 2.219973e-002
3149, -8.423386e-002, 3.948275e-003, 2.196002e-002
3150, -8.520078e-002, 3.779943e-003, 2.187972e-002
3151, -8.616522e-002, 3.599335e-003, 2.196052e-002
3152, -8.710241e-002, 3.411074e-003, 2.220055e-002
3153, -8.798772e-002, 3.220046e-003, 2.259427e-002
3154, -8.879673e-002, 3.031437e-003, 2.313187e-002
3155, -8.950528e-002, 2.850850e-003, 2.379769e-002
3156, -9.009199e-002, 2.683876e-003, 2.456980e-002
3157, -9.054433e-002, 2.534285e-003, 2.542916e-002
3158, -9.085129e-002, 2.405738e-003, 2.635457e-002
3159, -9.100439e-002, 2.301585e-003, 2.732308e-002
3160, -9.099815e-002, 2.224775e-003, 2.830987e-002
3161, -9.083082e-002, 2.177713e-003, 2.928843e-002
3162, -9.050529e-002, 2.162070e-003, 3.023106e-002
3163, -9.002979e-002, 2.178560e-003, 3.110985e-002
3164, -8.941852e-002, 2.226738e-003, 3.189796e-002
3165, -8.869224e-002, 2.304770e-003, 3.257102e-002
3166, -8.105495e-002, 1.695577e-003, 3.237446e-002
3167, -8.123144e-002, 2.657236e-003, 3.248129e-002
3168, -8.070329e-002, -2.206364e-004, 3.210407e-002
3169, -8.087793e-002, 7.364438e-004, 3.224794e-002
3170, -8.052889e-002, -1.174682e-003, 3.194113e-002
3171, -8.001448e-002, -4.017324e-003, 3.134394e-002
3172, -8.018440e-002, -3.073323e-003, 3.156098e-002
3173, -7.984446e-002, -4.956679e-003, 3.110764e-002
3174, -7.967561e-002, -5.891475e-003, 3.085312e-002
3175, -7.950744e-002, -6.821097e-003, 3.058005e-002
3176, -7.934067e-002, -7.745484e-003, 3.028907e-002
3177, -7.917486e-002, -8.664032e-003, 2.997988e-002
3178, -7.901023e-002, -9.576354e-003, 2.965276e-002
3179, -7.884672e-002, -1.048163e-002, 2.930784e-002
3180, -7.868488e-002, -1.137897e-002, 2.894587e-002
3181, -7.852506e-002, -1.226867e-002, 2.856718e-002
3182, -7.836730e-002, -1.315175e-002, 2.817155e-002
3183, -7.821143e-002, -1.402912e-002, 2.775850e-002
3184, -7.639225e-002, -1.217960e-002, 2.482216e-002
3185, -7.662493e-002, -1.265969e-002, 2.566073e-002
3186, -7.631965e-002, -1.171233e-002, 2.394790e-002
3187, -7.701328e-002, -1.313818e-002, 2.644439e-002
3188, -7.754685e-002, -1.359919e-002, 2.715006e-002
3189, -7.640805e-002, -1.127471e-002, 2.306471e-002
3190, -7.665314e-002, -1.087957e-002, 2.219432e-002
3191, -7.704723e-002, -1.053702e-002, 2.135987e-002
3192, -7.757948e-002, -1.025511e-002, 2.058286e-002
3193, -7.823809e-002, -1.003561e-002, 1.988444e-002
3194, -7.900929e-002, -9.875228e-003, 1.928721e-002
3195, -7.986969e-002, -9.782480e-003, 1.880842e-002
3196, -8.079298e-002, -9.765289e-003, 1.845929e-002
3197, -8.175323e-002, -9.826515e-003, 1.824723e-002
3198, -8.272488e-002, -9.965594e-003, 1.817651e-002
3199, -8.368287e-002, -1.017931e-002, 1.824846e-002
3200, -8.460267e-002, -1.046187e-002, 1.846178e-002
3201, -8.546022e-002, -1.080439e-002, 1.881246e-002
3202, -8.623213e-002, -1.119268e-002, 1.929381e-002
3203, -8.689664e-002, -1.160065e-002, 1.989674e-002
3204, -8.743599e-002, -1.202367e-002, 2.060102e-002
3205, -8.783637e-002, -1.245820e-002, 2.138549e-002
3206, -8.808711e-002, -1.289672e-002, 2.222903e-002
3207, -8.818011e-002, -1.333287e-002, 2.310862e-002
3208, -8.811018e-002, -1.376086e-002, 2.399965e-002
3209, -8.787637e-002, -1.417137e-002, 2.487681e-002
3210, -8.748408e-002, -1.455073e-002, 2.571388e-002
3211, -8.694660e-002, -1.488112e-002, 2.648704e-002
3212, -8.628013e-002, -1.514360e-002, 2.718140e-002
3213, -8.550739e-002, -1.532571e-002, 2.777776e-002
3214, -8.035569e-002, -2.125609e-003, 3.175990e-002
3215, -8.851757e-002, 1.340540e-003, 3.248567e-002
3216, -8.834332e-002, 3.780986e-004, 3.238125e-002
3217, -8.816963e-002, -5.821918e-004, 3.225775e-002
3218, -8.799652e-002, -1.539962e-003, 3.211525e-002
3219, -8.782403e-002, -2.494845e-003, 3.195384e-002
3220, -8.765217e-002, -3.446476e-003, 3.177360e-002
3221, -8.748098e-002, -4.394494e-003, 3.157463e-002
3222, -8.731052e-002, -5.338540e-003, 3.135701e-002
3223, -8.714084e-002, -6.278257e-003, 3.112082e-002
3224, -8.697202e-002, -7.213289e-003, 3.086615e-002
3225, -8.680413e-002, -8.143269e-003, 3.059310e-002
3226, -8.663717e-002, -9.067922e-003, 3.030178e-002
3227, -8.647010e-002, -9.987727e-003, 2.999273e-002
3228, -8.630008e-002, -1.090241e-002, 2.966815e-002
3229, -8.612935e-002, -1.180481e-002, 2.933009e-002
3230, -8.597574e-002, -1.268641e-002, 2.897017e-002
3231, -8.582221e-002, -1.356502e-002, 2.859193e-002
3232, -8.566607e-002, -1.444466e-002, 2.819474e-002
3233, -8.052793e-002, 2.850701e-003, 3.180983e-002
3234, -7.994293e-002, 3.034011e-003, 3.102440e-002
3235, -7.949568e-002, 3.201391e-003, 3.014825e-002
3236, -7.919961e-002, 3.347892e-003, 2.920713e-002
3237, -7.906283e-002, 3.469267e-003, 2.822913e-002
3238, -7.908776e-002, 3.562262e-003, 2.724273e-002
3239, -7.927174e-002, 3.624661e-003, 2.627516e-002
3240, -7.960813e-002, 3.655183e-003, 2.535155e-002
3241, -8.008731e-002, 3.653314e-003, 2.449472e-002
3242, -8.069762e-002, 3.619128e-003, 2.372517e-002
3243, -8.142705e-002, 3.553021e-003, 2.306080e-002
3244, -8.225323e-002, 3.456801e-003, 2.252427e-002
3245, -8.315145e-002, 3.333364e-003, 2.213142e-002
3246, -8.409661e-002, 3.186264e-003, 2.189222e-002
3247, -8.506358e-002, 3.019495e-003, 2.181212e-002
3248, -8.602752e-002, 2.837389e-003, 2.189277e-002
3249, -8.696373e-002, 2.644584e-003, 2.213234e-002
3250, -8.784767e-002, 2.446056e-003, 2.252534e-002
3251, -8.865489e-002, 2.247189e-003, 2.306202e-002
3252, -8.936112e-002, 2.053920e-003, 2.372663e-002
3253, -8.994507e-002, 1.872266e-003, 2.449719e-002
3254, -9.039436e-002, 1.706344e-003, 2.535466e-002
3255, -9.069818e-002, 1.560190e-003, 2.627801e-002
3256, -9.084815e-002, 1.437571e-003, 2.724447e-002
3257, -9.083880e-002, 1.341905e-003, 2.822943e-002
3258, -9.066839e-002, 1.276116e-003, 2.920651e-002
3259, -9.033975e-002, 1.242434e-003, 3.014796e-002
3260, -8.986121e-002, 1.242126e-003, 3.102571e-002
3261, -8.924718e-002, 1.275251e-003, 3.181278e-002
3262, -8.000524e-002, 1.208040e-005, 3.143330e-002
3263, -8.017851e-002, 9.559579e-004, 3.157689e-002
3264, -7.898844e-002, -5.580931e-003, 3.019482e-002
3265, -7.915455e-002, -4.658564e-003, 3.044535e-002
3266, -7.966081e-002, -1.866565e-003, 3.109097e-002
3267, -7.983178e-002, -9.285443e-004, 3.127031e-002
3268, -8.035281e-002, 1.902257e-003, 3.170246e-002
3269, -8.643788e-002, -1.426528e-002, 2.759701e-002
3270, -7.932188e-002, -3.731778e-003, 3.067812e-002
3271, -7.949009e-002, -2.800764e-003, 3.089271e-002
3272, -7.865865e-002, -7.409444e-003, 2.963919e-002
3273, -7.882204e-002, -6.497379e-003, 2.992484e-002
3274, -7.849604e-002, -8.314720e-003, 2.933551e-002
3275, -7.833483e-002, -9.212631e-003, 2.901469e-002
3276, -7.817354e-002, -1.010208e-002, 2.867518e-002
3277, -7.801415e-002, -1.098296e-002, 2.831952e-002
3278, -7.785668e-002, -1.185831e-002, 2.794727e-002
3279, -7.770072e-002, -1.272996e-002, 2.755738e-002
3280, -7.656116e-002, -1.042612e-002, 2.346485e-002
3281, -7.647325e-002, -1.086154e-002, 2.434625e-002
3282, -7.680495e-002, -1.003413e-002, 2.259398e-002
3283, -7.654502e-002, -1.132782e-002, 2.521834e-002
3284, -7.677719e-002, -1.180487e-002, 2.605847e-002
3285, -7.716544e-002, -1.227633e-002, 2.684550e-002
3286, -7.772654e-002, -9.422409e-003, 2.097745e-002
3287, -7.719721e-002, -9.695995e-003, 2.175789e-002
3288, -7.838491e-002, -9.207611e-003, 2.027439e-002
3289, -7.915533e-002, -9.055212e-003, 1.967168e-002
3290, -8.001502e-002, -8.970065e-003, 1.918805e-002
3291, -8.093783e-002, -8.958694e-003, 1.883535e-002
3292, -8.189792e-002, -9.023367e-003, 1.862123e-002
3293, -8.286977e-002, -9.163055e-003, 1.855011e-002
3294, -8.382824e-002, -9.374456e-003, 1.862327e-002
3295, -8.474886e-002, -9.651683e-003, 1.883930e-002
3296, -8.560771e-002, -9.985793e-003, 1.919414e-002
3297, -8.638148e-002, -1.036285e-002, 1.968085e-002
3298, -8.704826e-002, -1.075839e-002, 2.028939e-002
3299, -8.759017e-002, -1.116650e-002, 2.099989e-002
3300, -8.799351e-002, -1.158426e-002, 2.179118e-002
3301, -8.824729e-002, -1.200700e-002, 2.264140e-002
3302, -8.834270e-002, -1.243218e-002, 2.352704e-002
3303, -8.827368e-002, -1.285502e-002, 2.442440e-002
3304, -8.803786e-002, -1.326711e-002, 2.530769e-002
3305, -8.764080e-002, -1.365555e-002, 2.614587e-002
3306, -8.710308e-002, -1.399815e-002, 2.690748e-002
3307, -8.907490e-002, 3.256417e-004, 3.171025e-002
3308, -8.890323e-002, -6.218630e-004, 3.158877e-002
3309, -8.873225e-002, -1.566889e-003, 3.144839e-002
3310, -8.856194e-002, -2.509069e-003, 3.128924e-002
3311, -8.839231e-002, -3.448040e-003, 3.111144e-002
3312, -8.822338e-002, -4.383445e-003, 3.091511e-002
3313, -8.805519e-002, -5.314928e-003, 3.070036e-002
3314, -8.788779e-002, -6.242138e-003, 3.046727e-002
3315, -8.772126e-002, -7.164700e-003, 3.021592e-002
3316, -8.755567e-002, -8.082216e-003, 2.994645e-002
3317, -8.739025e-002, -8.995655e-003, 2.965914e-002
3318, -8.722112e-002, -9.908104e-003, 2.935643e-002
3319, -8.704045e-002, -1.081789e-002, 2.904732e-002
3320, -8.685227e-002, -1.170261e-002, 2.874024e-002
3321, -8.672764e-002, -1.253356e-002, 2.837823e-002
3322, -8.658917e-002, -1.339142e-002, 2.799577e-002
3323, -7.977165e-002, 2.100312e-003, 3.091878e-002
3324, -7.932846e-002, 2.284143e-003, 3.004495e-002
3325, -7.903634e-002, 2.448422e-003, 2.910608e-002
3326, -7.890347e-002, 2.588311e-003, 2.813040e-002
3327, -7.893220e-002, 2.699972e-003, 2.714657e-002
3328, -7.911971e-002, 2.780697e-003, 2.618171e-002
3329, -7.945926e-002, 2.828750e-003, 2.526071e-002
3330, -7.994125e-002, 2.843184e-003, 2.440615e-002
3331, -8.055411e-002, 2.823662e-003, 2.363843e-002
3332, -8.128584e-002, 2.770214e-003, 2.297548e-002
3333, -8.211390e-002, 2.684210e-003, 2.244009e-002
3334, -8.301350e-002, 2.568254e-003, 2.204809e-002
3335, -8.395943e-002, 2.425715e-003, 2.180944e-002
3336, -8.492659e-002, 2.260488e-003, 2.172955e-002
3337, -8.589013e-002, 2.076863e-003, 2.181003e-002
3338, -8.682546e-002, 1.879505e-003, 2.204908e-002
3339, -8.770806e-002, 1.673486e-003, 2.244126e-002
3340, -8.851345e-002, 1.464383e-003, 2.297683e-002
3341, -8.921734e-002, 1.258463e-003, 2.364000e-002
3342, -8.979858e-002, 1.062140e-003, 2.440884e-002
3343, -9.024488e-002, 8.799004e-004, 2.526434e-002
3344, -9.054553e-002, 7.161738e-004, 2.618549e-002
3345, -9.069226e-002, 5.751472e-004, 2.714964e-002
3346, -9.067970e-002, 4.606890e-004, 2.813239e-002
3347, -9.050610e-002, 3.762329e-004, 2.910749e-002
3348, -9.017432e-002, 3.245550e-004, 3.004722e-002
3349, -8.969275e-002, 3.074737e-004, 3.092343e-002
3350, -7.842722e-002, -5.261216e-003, 2.942651e-002
3351, -7.859021e-002, -4.353590e-003, 2.967202e-002
3352, -7.943014e-002, 2.401331e-004, 3.065202e-002
3353, -7.960018e-002, 1.169119e-003, 3.079378e-002
3354, -7.826524e-002, -6.163472e-003, 2.916338e-002
3355, -7.763724e-002, -9.690323e-003, 2.795416e-002
3356, -7.779817e-002, -8.824157e-003, 2.829110e-002
3357, -7.875492e-002, -3.441886e-003, 2.990111e-002
3358, -7.795219e-002, -7.948900e-003, 2.859778e-002
3359, -7.810718e-002, -7.060716e-003, 2.888754e-002
3360, -7.747798e-002, -1.055137e-002, 2.760109e-002
3361, -7.732037e-002, -1.141335e-002, 2.723108e-002
3362, -7.693232e-002, -1.094853e-002, 2.644302e-002
3363, -8.724895e-002, -1.311846e-002, 2.732055e-002
3364, -7.787478e-002, -8.558458e-003, 2.137018e-002
3365, -7.734715e-002, -8.831406e-003, 2.215385e-002
3366, -7.695856e-002, -9.166262e-003, 2.299043e-002
3367, -7.671708e-002, -9.558387e-003, 2.385942e-002
3368, -7.662965e-002, -9.999552e-003, 2.473956e-002
3369, -7.670113e-002, -1.047205e-002, 2.560715e-002
3370, -7.930224e-002, -8.201177e-003, 2.005249e-002
3371, -7.853270e-002, -8.345668e-003, 2.066217e-002
3372, -8.016217e-002, -8.122951e-003, 1.956268e-002
3373, -8.108539e-002, -8.117628e-003, 1.920522e-002
3374, -8.204632e-002, -8.186019e-003, 1.898821e-002
3375, -8.301943e-002, -8.325765e-003, 1.891654e-002
3376, -8.397939e-002, -8.533684e-003, 1.899126e-002
3377, -8.490170e-002, -8.803678e-003, 1.921076e-002
3378, -8.576255e-002, -9.126841e-003, 1.957072e-002
3379, -8.653870e-002, -9.490201e-003, 2.006362e-002
3380, -8.720782e-002, -9.873378e-003, 2.067760e-002
3381, -8.775199e-002, -1.026892e-002, 2.139323e-002
3382, -8.815763e-002, -1.067396e-002, 2.218961e-002
3383, -8.841333e-002, -1.108704e-002, 2.304421e-002
3384, -8.851024e-002, -1.150553e-002, 2.393543e-002
3385, -8.844116e-002, -1.192438e-002, 2.484256e-002
3386, -8.819991e-002, -1.233830e-002, 2.574176e-002
3387, -8.778667e-002, -1.274373e-002, 2.659481e-002
3388, -7.892128e-002, -2.526354e-003, 3.011366e-002
3389, -7.908933e-002, -1.607340e-003, 3.030976e-002
3390, -7.925863e-002, -6.849330e-004, 3.048868e-002
3391, -8.952345e-002, -6.250786e-004, 3.080462e-002
3392, -8.935484e-002, -1.555206e-003, 3.066704e-002
3393, -8.918698e-002, -2.482533e-003, 3.051080e-002
3394, -8.901987e-002, -3.406697e-003, 3.033605e-002
3395, -8.885350e-002, -4.327346e-003, 3.014295e-002
3396, -8.868790e-002, -5.244132e-003, 2.993165e-002
3397, -8.852318e-002, -6.156632e-003, 2.970217e-002
3398, -8.835950e-002, -7.063812e-003, 2.945486e-002
3399, -8.819631e-002, -7.966963e-003, 2.918984e-002
3400, -8.803074e-002, -8.871948e-003, 2.890792e-002
3401, -8.785510e-002, -9.786894e-003, 2.861539e-002
3402, -8.765504e-002, -1.070609e-002, 2.833649e-002
3403, -8.740596e-002, -1.157400e-002, 2.814044e-002
3404, -8.737002e-002, -1.226652e-002, 2.773112e-002
3405, -7.916114e-002, 1.369356e-003, 2.992235e-002
3406, -7.887313e-002, 1.551372e-003, 2.898584e-002
3407, -7.874442e-002, 1.709652e-003, 2.801301e-002
3408, -7.877713e-002, 1.839846e-003, 2.703244e-002
3409, -7.896821e-002, 1.938760e-003, 2.607105e-002
3410, -7.931085e-002, 2.004231e-003, 2.515336e-002
3411, -7.979555e-002, 2.034884e-003, 2.430159e-002
3412, -8.041090e-002, 2.029991e-003, 2.353605e-002
3413, -8.114487e-002, 1.989176e-003, 2.287481e-002
3414, -8.197474e-002, 1.913396e-003, 2.234079e-002
3415, -8.287563e-002, 1.804990e-003, 2.194980e-002
3416, -8.382233e-002, 1.667134e-003, 2.171177e-002
3417, -8.478979e-002, 1.503558e-003, 2.163208e-002
3418, -8.575309e-002, 1.318415e-003, 2.171236e-002
3419, -8.668760e-002, 1.116397e-003, 2.195081e-002
3420, -8.756885e-002, 9.027631e-004, 2.234203e-002
3421, -8.837239e-002, 6.833665e-004, 2.287628e-002
3422, -8.907392e-002, 4.648000e-004, 2.353775e-002
3423, -8.965249e-002, 2.538227e-004, 2.430465e-002
3424, -9.009582e-002, 5.525926e-005, 2.515795e-002
3425, -9.039327e-002, -1.259974e-004, 2.607660e-002
3426, -9.053674e-002, -2.853597e-004, 2.703808e-002
3427, -9.052094e-002, -4.185392e-004, 2.801823e-002
3428, -9.034413e-002, -5.216085e-004, 2.899097e-002
3429, -9.000918e-002, -5.912484e-004, 2.992860e-002
3430, -7.899385e-002, 4.574275e-004, 2.978062e-002
3431, -8.789646e-002, -1.179728e-002, 2.712733e-002
3432, -7.742021e-002, -8.431568e-003, 2.753692e-002
3433, -7.755845e-002, -7.592967e-003, 2.780465e-002
3434, -7.687502e-002, -8.671066e-003, 2.425822e-002
3435, -7.679030e-002, -9.123715e-003, 2.514095e-002
3436, -7.801144e-002, -4.944610e-003, 2.857600e-002
3437, -7.817068e-002, -4.052475e-003, 2.881418e-002
3438, -7.725639e-002, -9.253945e-003, 2.718780e-002
3439, -7.770332e-002, -6.722218e-003, 2.806720e-002
3440, -7.785498e-002, -5.835229e-003, 2.832550e-002
3441, -7.709245e-002, -1.009441e-002, 2.682023e-002
3442, -7.711268e-002, -8.278127e-003, 2.338545e-002
3443, -7.749719e-002, -7.944644e-003, 2.254512e-002
3444, -7.867727e-002, -7.460864e-003, 2.104358e-002
3445, -7.802248e-002, -7.670714e-003, 2.175681e-002
3446, -7.833205e-002, -3.157070e-003, 2.903821e-002
3447, -7.849523e-002, -2.258336e-003, 2.924730e-002
3448, -7.686228e-002, -9.620092e-003, 2.599871e-002
3449, -8.219685e-002, -7.320064e-003, 1.934389e-002
3450, -8.123374e-002, -7.247461e-003, 1.956489e-002
3451, -8.317259e-002, -7.459047e-003, 1.927151e-002
3452, -8.030886e-002, -7.247060e-003, 1.992841e-002
3453, -7.944840e-002, -7.318467e-003, 2.042589e-002
3454, -8.413525e-002, -7.662748e-003, 1.934785e-002
3455, -8.506014e-002, -7.924767e-003, 1.957105e-002
3456, -8.592360e-002, -8.236331e-003, 1.993633e-002
3457, -8.670232e-002, -8.585707e-003, 2.043535e-002
3458, -8.737375e-002, -8.957643e-003, 2.105443e-002
3459, -8.791960e-002, -9.344256e-003, 2.177403e-002
3460, -8.832618e-002, -9.742948e-003, 2.257296e-002
3461, -8.858238e-002, -1.015182e-002, 2.342912e-002
3462, -8.868049e-002, -1.056403e-002, 2.432512e-002
3463, -8.861266e-002, -1.097117e-002, 2.524571e-002
3464, -8.836544e-002, -1.137267e-002, 2.617863e-002
3465, -7.882641e-002, -4.510358e-004, 2.961920e-002
3466, -8.984343e-002, -1.504783e-003, 2.979427e-002
3467, -8.967840e-002, -2.415573e-003, 2.964144e-002
3468, -8.951412e-002, -3.323246e-003, 2.947026e-002
3469, -8.935061e-002, -4.227461e-003, 2.928091e-002
3470, -8.918800e-002, -5.127766e-003, 2.907335e-002
3471, -8.902660e-002, -6.021834e-003, 2.884847e-002
3472, -8.886626e-002, -6.909764e-003, 2.860662e-002
3473, -8.870577e-002, -7.797319e-003, 2.834659e-002
3474, -8.854109e-002, -8.697284e-003, 2.806793e-002
3475, -8.836478e-002, -9.627334e-003, 2.777322e-002
3476, -8.816320e-002, -1.061668e-002, 2.746795e-002
3477, -7.865967e-002, -1.355993e-003, 2.944006e-002
3478, -7.870998e-002, 6.572468e-004, 2.884609e-002
3479, -7.858575e-002, 8.338301e-004, 2.787641e-002
3480, -7.862269e-002, 9.823783e-004, 2.689978e-002
3481, -7.881744e-002, 1.099257e-003, 2.594274e-002
3482, -7.916303e-002, 1.181831e-003, 2.502929e-002
3483, -7.965021e-002, 1.228480e-003, 2.418106e-002
3484, -8.026794e-002, 1.238266e-003, 2.341813e-002
3485, -8.100389e-002, 1.210129e-003, 2.275903e-002
3486, -8.183518e-002, 1.144817e-003, 2.222675e-002
3487, -8.273714e-002, 1.044421e-003, 2.183694e-002
3488, -8.368486e-002, 9.117574e-004, 2.159949e-002
3489, -8.465303e-002, 7.500311e-004, 2.151992e-002
3490, -8.561640e-002, 5.632866e-004, 2.159994e-002
3491, -8.655030e-002, 3.563087e-004, 2.183769e-002
3492, -8.743026e-002, 1.346833e-004, 2.222780e-002
3493, -8.823185e-002, -9.534076e-005, 2.276049e-002
3494, -8.893097e-002, -3.267156e-004, 2.341998e-002
3495, -8.950693e-002, -5.525205e-004, 2.418479e-002
3496, -8.994725e-002, -7.675932e-004, 2.503565e-002
3497, -9.024142e-002, -9.663207e-004, 2.595134e-002
3498, -9.038160e-002, -1.143787e-003, 2.690965e-002
3499, -9.036258e-002, -1.295499e-003, 2.788676e-002
3500, -9.018259e-002, -1.417088e-003, 2.885676e-002
3501, -7.703697e-002, -7.754836e-003, 2.466261e-002
3502, -7.695942e-002, -8.219984e-003, 2.557021e-002
3503, -7.759662e-002, -5.528195e-003, 2.743687e-002
3504, -7.775115e-002, -4.646154e-003, 2.767540e-002
3505, -7.720196e-002, -8.067243e-003, 2.683732e-002
3506, -7.730482e-002, -7.291844e-003, 2.697189e-002
3507, -7.764676e-002, -7.043167e-003, 2.292605e-002
3508, -7.726865e-002, -7.370582e-003, 2.377186e-002
3509, -7.702931e-002, -8.796010e-003, 2.640377e-002
3510, -7.744584e-002, -6.420645e-003, 2.719910e-002
3511, -8.138159e-002, -6.356952e-003, 1.990936e-002
3512, -8.045318e-002, -6.352539e-003, 2.027985e-002
3513, -7.854704e-002, -2.334554e-004, 2.868706e-002
3514, -7.806497e-002, -2.887043e-003, 2.811896e-002
3515, -7.822423e-002, -2.005480e-003, 2.832211e-002
3516, -7.959027e-002, -6.419147e-003, 2.078679e-002
3517, -7.881914e-002, -6.558284e-003, 2.141410e-002
3518, -8.608968e-002, -7.326080e-003, 2.028525e-002
3519, -8.522282e-002, -7.024810e-003, 1.991481e-002
3520, -7.816712e-002, -6.769944e-003, 2.213301e-002
3521, -7.838473e-002, -1.120653e-003, 2.851053e-002
3522, -8.429428e-002, -6.770607e-003, 1.968796e-002
3523, -8.332755e-002, -6.571552e-003, 1.961005e-002
3524, -8.234837e-002, -6.431562e-003, 1.968437e-002
3525, -8.687096e-002, -7.663466e-003, 2.078987e-002
3526, -8.754454e-002, -8.027543e-003, 2.141369e-002
3527, -8.809100e-002, -8.411711e-003, 2.213604e-002
3528, -8.849671e-002, -8.811177e-003, 2.293560e-002
3529, -8.875109e-002, -9.221034e-003, 2.378912e-002
3530, -8.884999e-002, -9.624936e-003, 2.468529e-002
3531, -8.878761e-002, -1.000632e-002, 2.560991e-002
3532, -8.855773e-002, -1.035072e-002, 2.654382e-002
3533, -7.790723e-002, -3.766995e-003, 2.790310e-002
3534, -9.002082e-002, -2.310160e-003, 2.870757e-002
3535, -8.985973e-002, -3.200198e-003, 2.854025e-002
3536, -8.969939e-002, -4.086914e-003, 2.835481e-002
3537, -8.954008e-002, -4.967478e-003, 2.815286e-002
3538, -8.938195e-002, -5.839682e-003, 2.793610e-002
3539, -8.922502e-002, -6.705629e-003, 2.770266e-002
3540, -8.906848e-002, -7.574125e-003, 2.744665e-002
3541, -8.890785e-002, -8.461881e-003, 2.716822e-002
3542, -8.873860e-002, -9.383962e-003, 2.686801e-002
3543, -7.842756e-002, -3.872801e-005, 2.772112e-002
3544, -7.846889e-002, 1.278708e-004, 2.674935e-002
3545, -7.866709e-002, 2.620373e-004, 2.579786e-002
3546, -7.901500e-002, 3.607427e-004, 2.488981e-002
3547, -7.950396e-002, 4.227457e-004, 2.404586e-002
3548, -8.012397e-002, 4.477538e-004, 2.328571e-002
3549, -8.086098e-002, 4.327837e-004, 2.262946e-002
3550, -8.169296e-002, 3.787002e-004, 2.209919e-002
3551, -8.259632e-002, 2.870597e-004, 2.171019e-002
3552, -8.354601e-002, 1.598800e-004, 2.147286e-002
3553, -8.451578e-002, -4.361857e-008, 2.139315e-002
3554, -8.548000e-002, -1.884419e-004, 2.147282e-002
3555, -8.641390e-002, -4.003029e-004, 2.170996e-002
3556, -8.729289e-002, -6.299336e-004, 2.209902e-002
3557, -8.809245e-002, -8.710093e-004, 2.262997e-002
3558, -8.878904e-002, -1.115924e-003, 2.328729e-002
3559, -8.936241e-002, -1.357631e-003, 2.405011e-002
3560, -8.979942e-002, -1.589846e-003, 2.489823e-002
3561, -9.009005e-002, -1.805545e-003, 2.581037e-002
3562, -9.022684e-002, -2.000340e-003, 2.676455e-002
3563, -9.020469e-002, -2.169975e-003, 2.773791e-002
3564, -7.749088e-002, -5.248296e-003, 2.652402e-002
3565, -7.764745e-002, -4.370346e-003, 2.675546e-002
3566, -8.152836e-002, -5.456151e-003, 2.023385e-002
3567, -8.059561e-002, -5.448151e-003, 2.061218e-002
3568, -7.780237e-002, -3.504867e-003, 2.697168e-002
3569, -7.795744e-002, -2.640960e-003, 2.717476e-002
3570, -8.250006e-002, -5.536338e-003, 2.000285e-002
3571, -7.827002e-002, -9.081620e-004, 2.754974e-002
3572, -7.715959e-002, -7.188517e-003, 2.609139e-002
3573, -7.732945e-002, -6.169280e-003, 2.629255e-002
3574, -7.973024e-002, -5.509806e-003, 2.112962e-002
3575, -7.895928e-002, -5.647518e-003, 2.176679e-002
3576, -8.895728e-002, -9.070609e-003, 2.593914e-002
3577, -7.811327e-002, -1.775622e-003, 2.736705e-002
3578, -8.445511e-002, -5.871019e-003, 2.000607e-002
3579, -8.348282e-002, -5.679566e-003, 1.992569e-002
3580, -8.772036e-002, -7.096898e-003, 2.175328e-002
3581, -8.704398e-002, -6.735678e-003, 2.112354e-002
3582, -8.538792e-002, -6.116554e-003, 2.023683e-002
3583, -7.720583e-002, -6.801574e-003, 2.505767e-002
3584, -8.867091e-002, -7.894631e-003, 2.328360e-002
3585, -8.826689e-002, -7.488153e-003, 2.247960e-002
3586, -8.891812e-002, -8.314003e-003, 2.412725e-002
3587, -8.901496e-002, -8.713119e-003, 2.501643e-002
3588, -8.625824e-002, -6.407636e-003, 2.061228e-002
3589, -7.742685e-002, -6.453394e-003, 2.413677e-002
3590, -7.831022e-002, -5.864449e-003, 2.249095e-002
3591, -7.779747e-002, -6.142198e-003, 2.328065e-002
3592, -9.004699e-002, -3.042159e-003, 2.757462e-002
3593, -8.988994e-002, -3.910299e-003, 2.739537e-002
3594, -8.973384e-002, -4.771408e-003, 2.720411e-002
3595, -8.957898e-002, -5.623327e-003, 2.700289e-002
3596, -8.942588e-002, -6.466214e-003, 2.678452e-002
3597, -8.927487e-002, -7.306858e-003, 2.652749e-002
3598, -8.911924e-002, -8.173366e-003, 2.624323e-002
3599, -7.831523e-002, -7.243878e-004, 2.658473e-002
3600, -7.851555e-002, -5.745508e-004, 2.564095e-002
3601, -7.886351e-002, -4.622969e-004, 2.474010e-002
3602, -7.935185e-002, -3.873151e-004, 2.390092e-002
3603, -7.997382e-002, -3.455688e-004, 2.314256e-002
3604, -8.071105e-002, -3.459169e-004, 2.248883e-002
3605, -8.154433e-002, -3.879688e-004, 2.195913e-002
3606, -8.245092e-002, -4.708379e-004, 2.156932e-002
3607, -8.340432e-002, -5.929073e-004, 2.133113e-002
3608, -8.437711e-002, -7.512906e-004, 2.125088e-002
3609, -8.534343e-002, -9.408059e-004, 2.133031e-002
3610, -8.627847e-002, -1.156265e-003, 2.156733e-002
3611, -8.715746e-002, -1.392427e-003, 2.195605e-002
3612, -8.795558e-002, -1.644165e-003, 2.248589e-002
3613, -8.864956e-002, -1.904530e-003, 2.314129e-002
3614, -8.921980e-002, -2.165012e-003, 2.390220e-002
3615, -8.965280e-002, -2.415055e-003, 2.474748e-002
3616, -8.993947e-002, -2.645389e-003, 2.565567e-002
3617, -9.007253e-002, -2.855169e-003, 2.660391e-002
3618, -8.167533e-002, -4.562760e-003, 2.053126e-002
3619, -8.073966e-002, -4.547201e-003, 2.091803e-002
3620, -7.758675e-002, -5.553368e-003, 2.445291e-002
3621, -7.737740e-002, -5.862872e-003, 2.534871e-002
3622, -8.555247e-002, -5.216446e-003, 2.053187e-002
3623, -8.461286e-002, -4.984801e-003, 2.029539e-002
3624, -8.265098e-002, -4.650257e-003, 2.029421e-002
3625, -7.754020e-002, -4.969955e-003, 2.561117e-002
3626, -8.917536e-002, -7.833915e-003, 2.533028e-002
3627, -8.908448e-002, -7.444593e-003, 2.445595e-002
3628, -7.800589e-002, -2.424823e-003, 2.623387e-002
3629, -7.816084e-002, -1.575875e-003, 2.641220e-002
3630, -7.987284e-002, -4.600123e-003, 2.144638e-002
3631, -7.910212e-002, -4.735217e-003, 2.209338e-002
3632, -8.363681e-002, -4.798872e-003, 2.021378e-002
3633, -7.769583e-002, -4.113926e-003, 2.584994e-002
3634, -7.785042e-002, -3.271126e-003, 2.605085e-002
3635, -8.885739e-002, -7.000993e-003, 2.364081e-002
3636, -8.845254e-002, -6.570848e-003, 2.281466e-002
3637, -8.790069e-002, -6.173776e-003, 2.207218e-002
3638, -7.845274e-002, -4.962337e-003, 2.282455e-002
3639, -8.642849e-002, -5.495928e-003, 2.091381e-002
3640, -7.794348e-002, -5.259140e-003, 2.361033e-002
3641, -8.991935e-002, -3.707488e-003, 2.643391e-002
3642, -8.976796e-002, -4.555510e-003, 2.625926e-002
3643, -8.961941e-002, -5.394995e-003, 2.608647e-002
3644, -8.947435e-002, -6.215768e-003, 2.590649e-002
3645, -8.932874e-002, -7.002978e-003, 2.563101e-002
3646, -8.721934e-002, -5.814692e-003, 2.143274e-002
3647, -7.836018e-002, -1.412655e-003, 2.548013e-002
3648, -7.870270e-002, -1.292448e-003, 2.458984e-002
3649, -7.918341e-002, -1.213488e-003, 2.375588e-002
3650, -7.980794e-002, -1.153049e-003, 2.299386e-002
3651, -8.054818e-002, -1.136118e-003, 2.233775e-002
3652, -8.138661e-002, -1.165354e-003, 2.180456e-002
3653, -8.229950e-002, -1.239546e-003, 2.141174e-002
3654, -8.325857e-002, -1.356544e-003, 2.117181e-002
3655, -8.423574e-002, -1.513344e-003, 2.109076e-002
3656, -8.520535e-002, -1.702889e-003, 2.117027e-002
3657, -8.614279e-002, -1.919995e-003, 2.140795e-002
3658, -8.702355e-002, -2.160004e-003, 2.179779e-002
3659, -8.782202e-002, -2.420964e-003, 2.232846e-002
3660, -8.851340e-002, -2.700001e-003, 2.298276e-002
3661, -8.907939e-002, -2.983105e-003, 2.374182e-002
3662, -8.950824e-002, -3.250407e-003, 2.458648e-002
3663, -8.979086e-002, -3.487857e-003, 2.549274e-002
3664, -7.773736e-002, -4.695784e-003, 2.474127e-002
3665, -8.924822e-002, -6.635915e-003, 2.478254e-002
3666, -8.908204e-002, -6.109263e-003, 2.407570e-002
3667, -7.803764e-002, -3.075787e-003, 2.516707e-002
3668, -7.819955e-002, -2.250520e-003, 2.532290e-002
3669, -8.280208e-002, -3.785687e-003, 2.055572e-002
3670, -8.182602e-002, -3.695853e-003, 2.079502e-002
3671, -8.864244e-002, -5.651313e-003, 2.313318e-002
3672, -8.807751e-002, -5.261029e-003, 2.236185e-002
3673, -8.739059e-002, -4.910500e-003, 2.171169e-002
3674, -8.659170e-002, -4.610859e-003, 2.118209e-002
3675, -8.570861e-002, -4.350438e-003, 2.079237e-002
3676, -7.787841e-002, -3.882119e-003, 2.500492e-002
3677, -7.807022e-002, -4.421440e-003, 2.393239e-002
3678, -8.089141e-002, -3.664390e-003, 2.118939e-002
3679, -8.002511e-002, -3.699877e-003, 2.172791e-002
3680, -7.925122e-002, -3.819572e-003, 2.239123e-002
3681, -7.858793e-002, -4.052282e-003, 2.315214e-002
3682, -8.476649e-002, -4.125801e-003, 2.055386e-002
3683, -8.964702e-002, -4.334037e-003, 2.533354e-002
3684, -8.951276e-002, -5.179987e-003, 2.519840e-002
3685, -8.940178e-002, -5.992260e-003, 2.514225e-002
3686, -8.378914e-002, -3.941278e-003, 2.047239e-002
3687, -7.852799e-002, -2.130115e-003, 2.444953e-002
3688, -7.898316e-002, -2.078057e-003, 2.362285e-002
3689, -7.961965e-002, -1.994770e-003, 2.283743e-002
3690, -8.037207e-002, -1.955380e-003, 2.216906e-002
3691, -8.122113e-002, -1.968553e-003, 2.162894e-002
3692, -8.214263e-002, -2.032044e-003, 2.123250e-002
3693, -8.310842e-002, -2.142106e-003, 2.099110e-002
3694, -8.409035e-002, -2.297282e-003, 2.090925e-002
3695, -8.506346e-002, -2.486177e-003, 2.098907e-002
3696, -8.600360e-002, -2.704453e-003, 2.122768e-002
3697, -8.688738e-002, -2.946748e-003, 2.161968e-002
3698, -8.768803e-002, -3.216250e-003, 2.215292e-002
3699, -8.837694e-002, -3.517611e-003, 2.280659e-002
3700, -8.893963e-002, -3.826182e-003, 2.356651e-002
3701, -8.936693e-002, -4.109886e-003, 2.442018e-002
3702, -7.834309e-002, -2.951310e-003, 2.432906e-002
3703, -8.754505e-002, -4.046151e-003, 2.194894e-002
3704, -8.674232e-002, -3.767029e-003, 2.141405e-002
3705, -7.815048e-002, -3.685466e-003, 2.428123e-002
3706, -7.941521e-002, -2.891724e-003, 2.265503e-002
3707, -7.871431e-002, -3.037969e-003, 2.353192e-002
3708, -8.295477e-002, -2.955509e-003, 2.078551e-002
3709, -8.198303e-002, -2.857075e-003, 2.102617e-002
3710, -8.394022e-002, -3.111153e-003, 2.070257e-002
3711, -8.105397e-002, -2.808527e-003, 2.142326e-002
3712, -8.491556e-002, -3.299407e-003, 2.078265e-002
3713, -8.019266e-002, -2.819008e-003, 2.196699e-002
3714, -8.922905e-002, -5.023170e-003, 2.425371e-002
3715, -8.879689e-002, -4.712556e-003, 2.336941e-002
3716, -8.585641e-002, -3.521910e-003, 2.102078e-002
3717, -8.823198e-002, -4.374490e-003, 2.260079e-002
3718, -1.148892e-001, 1.736881e-001, 3.391811e-002
3719, -1.139437e-001, 1.738589e-001, 3.367473e-002
3720, -1.130507e-001, 1.740203e-001, 3.327660e-002
3721, -1.122345e-001, 1.741677e-001, 3.273466e-002
3722, -1.115172e-001, 1.742973e-001, 3.206360e-002
3723, -1.109183e-001, 1.744055e-001, 3.128164e-002
3724, -1.104542e-001, 1.744893e-001, 3.041015e-002
3725, -1.101376e-001, 1.745465e-001, 2.947290e-002
3726, -1.099771e-001, 1.745755e-001, 2.849547e-002
3727, -1.099771e-001, 1.745756e-001, 2.750452e-002
3728, -1.101376e-001, 1.745466e-001, 2.652709e-002
3729, -1.104542e-001, 1.744893e-001, 2.558983e-002
3730, -1.109184e-001, 1.744055e-001, 2.471831e-002
3731, -1.115173e-001, 1.742973e-001, 2.393631e-002
3732, -1.122348e-001, 1.741677e-001, 2.326516e-002
3733, -1.130512e-001, 1.740202e-001, 2.272316e-002
3734, -1.139442e-001, 1.738589e-001, 2.232510e-002
3735, -1.148895e-001, 1.736881e-001, 2.208183e-002
3736, -1.158614e-001, 1.735126e-001, 2.200000e-002
3737, -1.168332e-001, 1.733370e-001, 2.208183e-002
3738, -1.177785e-001, 1.731662e-001, 2.232510e-002
3739, -1.186716e-001, 1.730049e-001, 2.272316e-002
3740, -1.194879e-001, 1.728574e-001, 2.326516e-002
3741, -1.202054e-001, 1.727278e-001, 2.393631e-002
3742, -1.208043e-001, 1.726196e-001, 2.471831e-002
3743, -1.212685e-001, 1.725357e-001, 2.558983e-002
3744, -1.215851e-001, 1.724785e-001, 2.652709e-002
3745, -1.217456e-001, 1.724496e-001, 2.750452e-002
3746, -1.217456e-001, 1.724496e-001, 2.849548e-002
3747, -1.215851e-001, 1.724786e-001, 2.947291e-002
3748, -1.212685e-001, 1.725357e-001, 3.041017e-002
3749, -1.208043e-001, 1.726196e-001, 3.128169e-002
3750, -1.202054e-001, 1.727278e-001, 3.206369e-002
3751, -1.194879e-001, 1.728574e-001, 3.273484e-002
3752, -1.186716e-001, 1.730049e-001, 3.327684e-002
3753, -1.177785e-001, 1.731662e-001, 3.367490e-002
3754, -1.168332e-001, 1.733370e-001, 3.391817e-002
3755, -1.147106e-001, 1.727019e-001, 3.391804e-002
3756, -1.145319e-001, 1.717157e-001, 3.391796e-002
3757, -1.143532e-001, 1.707295e-001, 3.391787e-002
3758, -1.141745e-001, 1.697434e-001, 3.391778e-002
3759, -1.139959e-001, 1.687573e-001, 3.391770e-002
3760, -1.138172e-001, 1.677712e-001, 3.391760e-002
3761, -1.136383e-001, 1.667849e-001, 3.391749e-002
3762, -1.134596e-001, 1.657987e-001, 3.391740e-002
3763, -1.132812e-001, 1.648124e-001, 3.391735e-002
3764, -1.131028e-001, 1.638261e-001, 3.391732e-002
3765, -1.129246e-001, 1.628399e-001, 3.391731e-002
3766, -1.127464e-001, 1.618536e-001, 3.391731e-002
3767, -1.125682e-001, 1.608673e-001, 3.391731e-002
3768, -1.123900e-001, 1.598810e-001, 3.391731e-002
3769, -1.122119e-001, 1.588947e-001, 3.391731e-002
3770, -1.120337e-001, 1.579084e-001, 3.391731e-002
3771, -1.118555e-001, 1.569222e-001, 3.391731e-002
3772, -1.116774e-001, 1.559359e-001, 3.391731e-002
3773, -1.114992e-001, 1.549496e-001, 3.391731e-002
3774, -1.113210e-001, 1.539633e-001, 3.391731e-002
3775, -1.111428e-001, 1.529770e-001, 3.391731e-002
3776, -1.109647e-001, 1.519907e-001, 3.391731e-002
3777, -1.107865e-001, 1.510045e-001, 3.391731e-002
3778, -1.106083e-001, 1.500182e-001, 3.391731e-002
3779, -1.104301e-001, 1.490319e-001, 3.391731e-002
3780, -1.102520e-001, 1.480456e-001, 3.391731e-002
3781, -1.100738e-001, 1.470593e-001, 3.391731e-002
3782, -1.098956e-001, 1.460730e-001, 3.391731e-002
3783, -1.097175e-001, 1.450867e-001, 3.391731e-002
3784, -1.095393e-001, 1.441005e-001, 3.391731e-002
3785, -1.093611e-001, 1.431142e-001, 3.391731e-002
3786, -1.091829e-001, 1.421279e-001, 3.391731e-002
3787, -1.090048e-001, 1.411416e-001, 3.391731e-002
3788, -1.088266e-001, 1.401553e-001, 3.391731e-002
3789, -1.086484e-001, 1.391690e-001, 3.391731e-002
3790, -1.084702e-001, 1.381828e-001, 3.391731e-002
3791, -1.082921e-001, 1.371965e-001, 3.391731e-002
3792, -1.081139e-001, 1.362102e-001, 3.391731e-002
3793, -1.079357e-001, 1.352239e-001, 3.391731e-002
3794, -1.077576e-001, 1.342376e-001, 3.391731e-002
3795, -1.075794e-001, 1.332513e-001, 3.391731e-002
3796, -1.074012e-001, 1.322651e-001, 3.391731e-002
3797, -1.072230e-001, 1.312788e-001, 3.391731e-002
3798, -1.070449e-001, 1.302925e-001, 3.391731e-002
3799, -1.068667e-001, 1.293062e-001, 3.391731e-002
3800, -1.066885e-001, 1.283199e-001, 3.391731e-002
3801, -1.065103e-001, 1.273336e-001, 3.391731e-002
3802, -1.063322e-001, 1.263474e-001, 3.391731e-002
3803, -1.061540e-001, 1.253611e-001, 3.391731e-002
3804, -1.059758e-001, 1.243748e-001, 3.391731e-002
3805, -1.057977e-001, 1.233885e-001, 3.391731e-002
3806, -1.056195e-001, 1.224022e-001, 3.391731e-002
3807, -1.054413e-001, 1.214159e-001, 3.391731e-002
3808, -1.052631e-001, 1.204296e-001, 3.391731e-002
3809, -1.050850e-001, 1.194434e-001, 3.391731e-002
3810, -1.049068e-001, 1.184571e-001, 3.391731e-002
3811, -1.047286e-001, 1.174708e-001, 3.391731e-002
3812, -1.045505e-001, 1.164845e-001, 3.391731e-002
3813, -1.043723e-001, 1.154982e-001, 3.391731e-002
3814, -1.041941e-001, 1.145119e-001, 3.391731e-002
3815, -1.040159e-001, 1.135257e-001, 3.391731e-002
3816, -1.038378e-001, 1.125394e-001, 3.391731e-002
3817, -1.036596e-001, 1.115531e-001, 3.391731e-002
3818, -1.034814e-001, 1.105668e-001, 3.391731e-002
3819, -1.033032e-001, 1.095805e-001, 3.391731e-002
3820, -1.031251e-001, 1.085942e-001, 3.391731e-002
3821, -1.029469e-001, 1.076080e-001, 3.391731e-002
3822, -1.027687e-001, 1.066217e-001, 3.391731e-002
3823, -1.025906e-001, 1.056354e-001, 3.391731e-002
3824, -1.024124e-001, 1.046491e-001, 3.391731e-002
3825, -1.022342e-001, 1.036628e-001, 3.391731e-002
3826, -1.020560e-001, 1.026765e-001, 3.391731e-002
3827, -1.018779e-001, 1.016902e-001, 3.391731e-002
3828, -1.016997e-001, 1.007040e-001, 3.391731e-002
3829, -1.015215e-001, 9.971768e-002, 3.391731e-002
3830, -1.013433e-001, 9.873139e-002, 3.391731e-002
3831, -1.011652e-001, 9.774511e-002, 3.391731e-002
3832, -1.009870e-001, 9.675883e-002, 3.391731e-002
3833, -1.008088e-001, 9.577254e-002, 3.391731e-002
3834, -1.006307e-001, 9.478626e-002, 3.391731e-002
3835, -1.004525e-001, 9.379997e-002, 3.391731e-002
3836, -1.002743e-001, 9.281369e-002, 3.391731e-002
3837, -1.000961e-001, 9.182740e-002, 3.391731e-002
3838, -9.991796e-002, 9.084112e-002, 3.391731e-002
3839, -9.973979e-002, 8.985484e-002, 3.391731e-002
3840, -9.956162e-002, 8.886855e-002, 3.391731e-002
3841, -9.938345e-002, 8.788227e-002, 3.391731e-002
3842, -9.920527e-002, 8.689598e-002, 3.391731e-002
3843, -9.902710e-002, 8.590970e-002, 3.391731e-002
3844, -9.884893e-002, 8.492342e-002, 3.391731e-002
3845, -9.867076e-002, 8.393713e-002, 3.391731e-002
3846, -9.849258e-002, 8.295085e-002, 3.391731e-002
3847, -9.831441e-002, 8.196456e-002, 3.391731e-002
3848, -9.813624e-002, 8.097828e-002, 3.391731e-002
3849, -9.795807e-002, 7.999200e-002, 3.391731e-002
3850, -9.777989e-002, 7.900571e-002, 3.391731e-002
3851, -9.760172e-002, 7.801943e-002, 3.391731e-002
3852, -9.742355e-002, 7.703314e-002, 3.391731e-002
3853, -9.724538e-002, 7.604686e-002, 3.391731e-002
3854, -9.706720e-002, 7.506057e-002, 3.391731e-002
3855, -9.688903e-002, 7.407429e-002, 3.391731e-002
3856, -9.671086e-002, 7.308801e-002, 3.391731e-002
3857, -9.653269e-002, 7.210172e-002, 3.391731e-002
3858, -9.635451e-002, 7.111544e-002, 3.391731e-002
3859, -9.617634e-002, 7.012915e-002, 3.391731e-002
3860, -9.599817e-002, 6.914287e-002, 3.391731e-002
3861, -9.582000e-002, 6.815659e-002, 3.391731e-002
3862, -9.564182e-002, 6.717030e-002, 3.391731e-002
3863, -9.546365e-002, 6.618402e-002, 3.391731e-002
3864, -9.528548e-002, 6.519773e-002, 3.391731e-002
3865, -9.510731e-002, 6.421145e-002, 3.391731e-002
3866, -9.492913e-002, 6.322516e-002, 3.391731e-002
3867, -9.475096e-002, 6.223888e-002, 3.391731e-002
3868, -9.457279e-002, 6.125260e-002, 3.391731e-002
3869, -9.439461e-002, 6.026631e-002, 3.391731e-002
3870, -9.421644e-002, 5.928003e-002, 3.391731e-002
3871, -9.403827e-002, 5.829374e-002, 3.391731e-002
3872, -9.386010e-002, 5.730746e-002, 3.391731e-002
3873, -9.368192e-002, 5.632118e-002, 3.391731e-002
3874, -9.350375e-002, 5.533489e-002, 3.391731e-002
3875, -9.332558e-002, 5.434861e-002, 3.391731e-002
3876, -9.314741e-002, 5.336232e-002, 3.391731e-002
3877, -9.296923e-002, 5.237604e-002, 3.391731e-002
3878, -9.279106e-002, 5.138975e-002, 3.391731e-002
3879, -9.261289e-002, 5.040347e-002, 3.391731e-002
3880, -9.243472e-002, 4.941719e-002, 3.391731e-002
3881, -9.225654e-002, 4.843090e-002, 3.391731e-002
3882, -9.207837e-002, 4.744462e-002, 3.391731e-002
3883, -9.190020e-002, 4.645833e-002, 3.391731e-002
3884, -9.172203e-002, 4.547205e-002, 3.391731e-002
3885, -9.154385e-002, 4.448577e-002, 3.391731e-002
3886, -9.136568e-002, 4.349948e-002, 3.391731e-002
3887, -9.118751e-002, 4.251320e-002, 3.391731e-002
3888, -9.100934e-002, 4.152691e-002, 3.391731e-002
3889, -9.083116e-002, 4.054063e-002, 3.391731e-002
3890, -9.065299e-002, 3.955434e-002, 3.391731e-002
3891, -9.047482e-002, 3.856806e-002, 3.391731e-002
3892, -9.029665e-002, 3.758178e-002, 3.391731e-002
3893, -9.011847e-002, 3.659549e-002, 3.391731e-002
3894, -8.994030e-002, 3.560921e-002, 3.391731e-002
3895, -8.976213e-002, 3.462292e-002, 3.391731e-002
3896, -8.958396e-002, 3.363664e-002, 3.391731e-002
3897, -8.940578e-002, 3.265036e-002, 3.391731e-002
3898, -8.922761e-002, 3.166407e-002, 3.391731e-002
3899, -8.904944e-002, 3.067779e-002, 3.391731e-002
3900, -8.887127e-002, 2.969150e-002, 3.391731e-002
3901, -8.869309e-002, 2.870522e-002, 3.391731e-002
3902, -8.851492e-002, 2.771894e-002, 3.391731e-002
