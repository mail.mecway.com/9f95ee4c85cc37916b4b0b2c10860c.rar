*node, nset=Nall
1, -7.922615e-002, -2.928368e-002, 7.000000e-003
2, -8.112809e-002, -1.875537e-002, 2.703332e-002
3, -8.219473e-002, -1.285094e-002, 1.664102e-002
4, -8.575019e-002, 6.830492e-003, 3.400000e-002
5, -1.160395e-001, 1.744988e-001, 3.400000e-002
6, -1.219816e-001, 2.073913e-001, 2.183431e-002
7, -1.251244e-001, 2.247886e-001, 7.000000e-003
8, -2.451252e-001, 3.150633e-001, 6.023068e-018
9, -2.490501e-001, 3.276243e-001, 6.413154e-023
10, -1.376059e-001, 2.391894e-001, 4.544926e-018
11, -1.459627e-001, 2.548779e-001, 1.143537e-022
12, -2.131952e-001, 2.087077e-001, -1.903956e-018
13, -2.144860e-001, 2.166256e-001, 2.024811e-016
14, -1.329273e-001, 2.280446e-001, 2.585795e-014
15, -1.357176e-001, 2.356013e-001, -1.682737e-017
16, -1.282811e-001, 2.028865e-001, 8.572528e-019
17, -1.145041e-001, 2.053753e-001, -1.714506e-018
18, -2.267136e-001, 4.064760e-001, 0.000000e+000
19, -2.143573e-001, 4.130578e-001, 8.572528e-019
20, -1.239346e-001, 2.433026e-001, 0.000000e+000
21, -1.362910e-001, 2.367208e-001, 0.000000e+000
22, -1.185565e-001, 2.278077e-001, 0.000000e+000
23, -1.323335e-001, 2.253189e-001, 0.000000e+000
24, -8.315930e-002, -1.306677e-002, 1.671188e-002
25, -8.408300e-002, -1.335723e-002, 1.692256e-002
26, -8.494065e-002, -1.371442e-002, 1.726729e-002
27, -8.570885e-002, -1.412858e-002, 1.773667e-002
28, -8.636665e-002, -1.458842e-002, 1.831791e-002
29, -8.689610e-002, -1.508140e-002, 1.899514e-002
30, -8.728276e-002, -1.559406e-002, 1.974990e-002
31, -8.751609e-002, -1.611243e-002, 2.056159e-002
32, -8.758972e-002, -1.662236e-002, 2.140807e-002
33, -8.750164e-002, -1.710994e-002, 2.226626e-002
34, -8.725425e-002, -1.756188e-002, 2.311275e-002
35, -8.685430e-002, -1.796584e-002, 2.392444e-002
36, -8.631271e-002, -1.831081e-002, 2.467919e-002
37, -8.564424e-002, -1.858738e-002, 2.535643e-002
38, -8.486713e-002, -1.878801e-002, 2.593766e-002
39, -8.400257e-002, -1.890721e-002, 2.640705e-002
40, -8.307416e-002, -1.894175e-002, 2.675178e-002
41, -8.210721e-002, -1.889067e-002, 2.696245e-002
42, -8.203849e-002, -1.371582e-002, 1.613359e-002
43, -8.188225e-002, -1.458070e-002, 1.562617e-002
44, -8.172601e-002, -1.544558e-002, 1.511875e-002
45, -8.156977e-002, -1.631046e-002, 1.461133e-002
46, -8.141353e-002, -1.717535e-002, 1.410391e-002
47, -8.125729e-002, -1.804023e-002, 1.359648e-002
48, -8.110104e-002, -1.890511e-002, 1.308906e-002
49, -8.094480e-002, -1.976999e-002, 1.258164e-002
50, -8.078856e-002, -2.063487e-002, 1.207422e-002
51, -8.063232e-002, -2.149975e-002, 1.156680e-002
52, -8.047608e-002, -2.236463e-002, 1.105938e-002
53, -8.031984e-002, -2.322951e-002, 1.055195e-002
54, -8.016360e-002, -2.409440e-002, 1.004453e-002
55, -8.000736e-002, -2.495928e-002, 9.537110e-003
56, -7.985112e-002, -2.582416e-002, 9.029688e-003
57, -7.969487e-002, -2.668904e-002, 8.522266e-003
58, -7.953863e-002, -2.755392e-002, 8.014844e-003
59, -7.938239e-002, -2.841880e-002, 7.507422e-003
60, -7.824683e-002, -2.937333e-002, 6.935539e-003
61, -7.738121e-002, -2.983695e-002, 6.786107e-003
62, -7.664188e-002, -3.047766e-002, 6.600541e-003
63, -7.599470e-002, -3.120803e-002, 6.398947e-003
64, -7.541438e-002, -3.199082e-002, 6.189592e-003
65, -7.488584e-002, -3.280860e-002, 5.976404e-003
66, -7.439771e-002, -3.365082e-002, 5.761837e-003
67, -7.394338e-002, -3.451183e-002, 5.547445e-003
68, -7.351723e-002, -3.538748e-002, 5.334466e-003
69, -7.311636e-002, -3.627562e-002, 5.124111e-003
70, -7.273818e-002, -3.717455e-002, 4.917587e-003
71, -7.237995e-002, -3.808274e-002, 4.716030e-003
72, -7.204008e-002, -3.899932e-002, 4.520730e-003
73, -7.171805e-002, -3.992409e-002, 4.334016e-003
74, -7.141334e-002, -4.085686e-002, 4.158385e-003
75, -7.112547e-002, -4.179742e-002, 3.996425e-003
76, -7.085515e-002, -4.274609e-002, 3.852629e-003
77, -7.060389e-002, -4.370331e-002, 3.733069e-003
78, -7.037488e-002, -4.466960e-002, 3.646704e-003
79, -7.017393e-002, -4.564503e-002, 3.606505e-003
80, -7.001189e-002, -4.662800e-002, 3.631835e-003
81, -6.990888e-002, -4.761172e-002, 3.750298e-003
82, -6.989936e-002, -4.857675e-002, 3.994457e-003
83, -7.002908e-002, -4.948399e-002, 4.381106e-003
84, -7.033330e-002, -5.028804e-002, 4.881365e-003
85, -7.081384e-002, -5.096881e-002, 5.425310e-003
86, -7.144809e-002, -5.153496e-002, 5.943159e-003
87, -7.220746e-002, -5.200305e-002, 6.385456e-003
88, -7.306437e-002, -5.238343e-002, 6.720836e-003
89, -7.399067e-002, -5.268332e-002, 6.929556e-003
90, -7.495967e-002, -5.290142e-002, 7.000002e-003
91, -7.594375e-002, -5.303618e-002, 6.929597e-003
92, -7.691642e-002, -5.307926e-002, 6.720797e-003
93, -7.785228e-002, -5.302286e-002, 6.385489e-003
94, -7.872735e-002, -5.284989e-002, 5.943104e-003
95, -7.951963e-002, -5.254149e-002, 5.425254e-003
96, -8.020791e-002, -5.207180e-002, 4.881318e-003
97, -8.077422e-002, -5.142505e-002, 4.381021e-003
98, -8.121322e-002, -5.062055e-002, 3.994325e-003
99, -8.154185e-002, -4.971313e-002, 3.750307e-003
100, -8.178962e-002, -4.875557e-002, 3.631748e-003
101, -8.198196e-002, -4.777810e-002, 3.606213e-003
102, -8.213469e-002, -4.679397e-002, 3.646721e-003
103, -8.225828e-002, -4.580864e-002, 3.733034e-003
104, -8.235779e-002, -4.482401e-002, 3.852647e-003
105, -8.243648e-002, -4.384072e-002, 3.996427e-003
106, -8.249588e-002, -4.285889e-002, 4.158415e-003
107, -8.253678e-002, -4.187846e-002, 4.334052e-003
108, -8.255869e-002, -4.089947e-002, 4.520742e-003
109, -8.256100e-002, -3.992191e-002, 4.716031e-003
110, -8.254314e-002, -3.894579e-002, 4.917601e-003
111, -8.250337e-002, -3.797136e-002, 5.124128e-003
112, -8.243861e-002, -3.699909e-002, 5.334479e-003
113, -8.234578e-002, -3.602968e-002, 5.547453e-003
114, -8.222143e-002, -3.506414e-002, 5.761846e-003
115, -8.205882e-002, -3.410436e-002, 5.976413e-003
116, -8.184976e-002, -3.315335e-002, 6.189598e-003
117, -8.158005e-002, -3.221698e-002, 6.398957e-003
118, -8.122932e-002, -3.130634e-002, 6.600550e-003
119, -8.076089e-002, -3.044745e-002, 6.786115e-003
120, -8.011221e-002, -2.971031e-002, 6.935540e-003
121, -8.016353e-002, -1.853954e-002, 2.696245e-002
122, -7.923983e-002, -1.824907e-002, 2.675178e-002
123, -7.838218e-002, -1.789189e-002, 2.640705e-002
124, -7.761397e-002, -1.747772e-002, 2.593766e-002
125, -7.695618e-002, -1.701788e-002, 2.535643e-002
126, -7.642673e-002, -1.652491e-002, 2.467919e-002
127, -7.604006e-002, -1.601225e-002, 2.392444e-002
128, -7.580674e-002, -1.549388e-002, 2.311275e-002
129, -7.573311e-002, -1.498395e-002, 2.226626e-002
130, -7.582119e-002, -1.449637e-002, 2.140807e-002
131, -7.606858e-002, -1.404443e-002, 2.056159e-002
132, -7.646853e-002, -1.364046e-002, 1.974990e-002
133, -7.701012e-002, -1.329549e-002, 1.899514e-002
134, -7.767859e-002, -1.301892e-002, 1.831791e-002
135, -7.845570e-002, -1.281830e-002, 1.773667e-002
136, -7.932026e-002, -1.269909e-002, 1.726729e-002
137, -8.024867e-002, -1.266456e-002, 1.692256e-002
138, -8.121562e-002, -1.271564e-002, 1.671188e-002
139, -8.477835e-002, 7.006055e-003, 3.391817e-002
140, -8.383302e-002, 7.176829e-003, 3.367490e-002
141, -8.293999e-002, 7.338156e-003, 3.327684e-002
142, -8.212361e-002, 7.485635e-003, 3.273484e-002
143, -8.140616e-002, 7.615243e-003, 3.206369e-002
144, -8.080720e-002, 7.723445e-003, 3.128169e-002
145, -8.034307e-002, 7.807290e-003, 3.041017e-002
146, -8.002643e-002, 7.864491e-003, 2.947291e-002
147, -7.986593e-002, 7.893486e-003, 2.849548e-002
148, -7.986593e-002, 7.893486e-003, 2.750452e-002
149, -8.002643e-002, 7.864491e-003, 2.652709e-002
150, -8.034307e-002, 7.807290e-003, 2.558983e-002
151, -8.080720e-002, 7.723445e-003, 2.471831e-002
152, -8.140616e-002, 7.615243e-003, 2.393631e-002
153, -8.212361e-002, 7.485635e-003, 2.326516e-002
154, -8.293999e-002, 7.338156e-003, 2.272316e-002
155, -8.383302e-002, 7.176829e-003, 2.232510e-002
156, -8.477835e-002, 7.006055e-003, 2.208183e-002
157, -8.575019e-002, 6.830492e-003, 2.200000e-002
158, -8.672203e-002, 6.654930e-003, 2.208183e-002
159, -8.766735e-002, 6.484156e-003, 2.232510e-002
160, -8.856039e-002, 6.322829e-003, 2.272316e-002
161, -8.937676e-002, 6.175350e-003, 2.326516e-002
162, -9.009422e-002, 6.045742e-003, 2.393631e-002
163, -9.069318e-002, 5.937540e-003, 2.471831e-002
164, -9.115731e-002, 5.853695e-003, 2.558983e-002
165, -9.147394e-002, 5.796494e-003, 2.652709e-002
166, -9.163445e-002, 5.767498e-003, 2.750452e-002
167, -9.163445e-002, 5.767498e-003, 2.849548e-002
168, -9.147394e-002, 5.796494e-003, 2.947291e-002
169, -9.115731e-002, 5.853695e-003, 3.041017e-002
170, -9.069318e-002, 5.937540e-003, 3.128169e-002
171, -9.009422e-002, 6.045742e-003, 3.206369e-002
172, -8.937676e-002, 6.175350e-003, 3.273484e-002
173, -8.856039e-002, 6.322829e-003, 3.327684e-002
174, -8.766735e-002, 6.484156e-003, 3.367490e-002
175, -8.672203e-002, 6.654930e-003, 3.391817e-002
176, -8.557093e-002, 5.838205e-003, 3.399022e-002
177, -8.539174e-002, 4.846290e-003, 3.396089e-002
178, -8.521269e-002, 3.855122e-003, 3.391201e-002
179, -8.503384e-002, 2.865073e-003, 3.384362e-002
180, -8.485525e-002, 1.876515e-003, 3.375573e-002
181, -8.467700e-002, 8.898203e-004, 3.364838e-002
182, -8.449916e-002, -9.464095e-005, 3.352160e-002
183, -8.432179e-002, -1.076498e-003, 3.337546e-002
184, -8.414495e-002, -2.055382e-003, 3.320999e-002
185, -8.396872e-002, -3.030924e-003, 3.302527e-002
186, -8.379316e-002, -4.002758e-003, 3.282136e-002
187, -8.361833e-002, -4.970518e-003, 3.259833e-002
188, -8.344431e-002, -5.933840e-003, 3.235628e-002
189, -8.327115e-002, -6.892361e-003, 3.209528e-002
190, -8.309893e-002, -7.845721e-003, 3.181545e-002
191, -8.292770e-002, -8.793562e-003, 3.151688e-002
192, -8.275753e-002, -9.735527e-003, 3.119970e-002
193, -8.258849e-002, -1.067126e-002, 3.086401e-002
194, -8.242064e-002, -1.160042e-002, 3.050994e-002
195, -8.225404e-002, -1.252264e-002, 3.013763e-002
196, -8.208875e-002, -1.343758e-002, 2.974722e-002
197, -8.192485e-002, -1.434491e-002, 2.933886e-002
198, -8.176238e-002, -1.524427e-002, 2.891269e-002
199, -8.160141e-002, -1.613533e-002, 2.846889e-002
200, -8.144200e-002, -1.701775e-002, 2.800761e-002
201, -8.128421e-002, -1.789121e-002, 2.752903e-002
202, -1.150677e-001, 1.746744e-001, 3.391817e-002
203, -1.141224e-001, 1.748451e-001, 3.367490e-002
204, -1.132293e-001, 1.750065e-001, 3.327684e-002
205, -1.124130e-001, 1.751539e-001, 3.273484e-002
206, -1.116955e-001, 1.752835e-001, 3.206369e-002
207, -1.110965e-001, 1.753918e-001, 3.128169e-002
208, -1.106324e-001, 1.754756e-001, 3.041017e-002
209, -1.103158e-001, 1.755328e-001, 2.947291e-002
210, -1.101553e-001, 1.755618e-001, 2.849548e-002
211, -1.101553e-001, 1.755618e-001, 2.750452e-002
212, -1.103158e-001, 1.755328e-001, 2.652709e-002
213, -1.106324e-001, 1.754756e-001, 2.558983e-002
214, -1.110965e-001, 1.753918e-001, 2.471831e-002
215, -1.116955e-001, 1.752835e-001, 2.393631e-002
216, -1.124130e-001, 1.751539e-001, 2.326516e-002
217, -1.132293e-001, 1.750065e-001, 2.272316e-002
218, -1.141224e-001, 1.748451e-001, 2.232510e-002
219, -1.150677e-001, 1.746744e-001, 2.208183e-002
220, -1.160395e-001, 1.744988e-001, 2.200000e-002
221, -1.170114e-001, 1.743232e-001, 2.208183e-002
222, -1.179567e-001, 1.741525e-001, 2.232510e-002
223, -1.188497e-001, 1.739911e-001, 2.272316e-002
224, -1.196661e-001, 1.738437e-001, 2.326516e-002
225, -1.203836e-001, 1.737140e-001, 2.393631e-002
226, -1.209825e-001, 1.736058e-001, 2.471831e-002
227, -1.214466e-001, 1.735220e-001, 2.558983e-002
228, -1.217633e-001, 1.734648e-001, 2.652709e-002
229, -1.219238e-001, 1.734358e-001, 2.750452e-002
230, -1.219238e-001, 1.734358e-001, 2.849548e-002
231, -1.217633e-001, 1.734648e-001, 2.947291e-002
232, -1.214466e-001, 1.735220e-001, 3.041017e-002
233, -1.209825e-001, 1.736058e-001, 3.128169e-002
234, -1.203836e-001, 1.737140e-001, 3.206369e-002
235, -1.196661e-001, 1.738437e-001, 3.273484e-002
236, -1.188497e-001, 1.739911e-001, 3.327684e-002
237, -1.179567e-001, 1.741525e-001, 3.367490e-002
238, -1.170114e-001, 1.743232e-001, 3.391817e-002
239, -1.158614e-001, 1.735125e-001, 3.400000e-002
240, -1.156832e-001, 1.725262e-001, 3.400000e-002
241, -1.155050e-001, 1.715399e-001, 3.400000e-002
242, -1.153268e-001, 1.705537e-001, 3.400000e-002
243, -1.151487e-001, 1.695674e-001, 3.400000e-002
244, -1.149705e-001, 1.685811e-001, 3.400000e-002
245, -1.147923e-001, 1.675948e-001, 3.400000e-002
246, -1.146141e-001, 1.666085e-001, 3.400000e-002
247, -1.144360e-001, 1.656222e-001, 3.400000e-002
248, -1.142578e-001, 1.646360e-001, 3.400000e-002
249, -1.140796e-001, 1.636497e-001, 3.400000e-002
250, -1.139015e-001, 1.626634e-001, 3.400000e-002
251, -1.137233e-001, 1.616771e-001, 3.400000e-002
252, -1.135451e-001, 1.606908e-001, 3.400000e-002
253, -1.133669e-001, 1.597045e-001, 3.400000e-002
254, -1.131888e-001, 1.587183e-001, 3.400000e-002
255, -1.130106e-001, 1.577320e-001, 3.400000e-002
256, -1.128324e-001, 1.567457e-001, 3.400000e-002
257, -1.126542e-001, 1.557594e-001, 3.400000e-002
258, -1.124761e-001, 1.547731e-001, 3.400000e-002
259, -1.122979e-001, 1.537868e-001, 3.400000e-002
260, -1.121197e-001, 1.528005e-001, 3.400000e-002
261, -1.119416e-001, 1.518143e-001, 3.400000e-002
262, -1.117634e-001, 1.508280e-001, 3.400000e-002
263, -1.115852e-001, 1.498417e-001, 3.400000e-002
264, -1.114070e-001, 1.488554e-001, 3.400000e-002
265, -1.112289e-001, 1.478691e-001, 3.400000e-002
266, -1.110507e-001, 1.468828e-001, 3.400000e-002
267, -1.108725e-001, 1.458966e-001, 3.400000e-002
268, -1.106943e-001, 1.449103e-001, 3.400000e-002
269, -1.105162e-001, 1.439240e-001, 3.400000e-002
270, -1.103380e-001, 1.429377e-001, 3.400000e-002
271, -1.101598e-001, 1.419514e-001, 3.400000e-002
272, -1.099817e-001, 1.409651e-001, 3.400000e-002
273, -1.098035e-001, 1.399789e-001, 3.400000e-002
274, -1.096253e-001, 1.389926e-001, 3.400000e-002
275, -1.094471e-001, 1.380063e-001, 3.400000e-002
276, -1.092690e-001, 1.370200e-001, 3.400000e-002
277, -1.090908e-001, 1.360337e-001, 3.400000e-002
278, -1.089126e-001, 1.350474e-001, 3.400000e-002
279, -1.087345e-001, 1.340611e-001, 3.400000e-002
280, -1.085563e-001, 1.330749e-001, 3.400000e-002
281, -1.083781e-001, 1.320886e-001, 3.400000e-002
282, -1.081999e-001, 1.311023e-001, 3.400000e-002
283, -1.080218e-001, 1.301160e-001, 3.400000e-002
284, -1.078436e-001, 1.291297e-001, 3.400000e-002
285, -1.076654e-001, 1.281434e-001, 3.400000e-002
286, -1.074872e-001, 1.271572e-001, 3.400000e-002
287, -1.073091e-001, 1.261709e-001, 3.400000e-002
288, -1.071309e-001, 1.251846e-001, 3.400000e-002
289, -1.069527e-001, 1.241983e-001, 3.400000e-002
290, -1.067746e-001, 1.232120e-001, 3.400000e-002
291, -1.065964e-001, 1.222257e-001, 3.400000e-002
292, -1.064182e-001, 1.212395e-001, 3.400000e-002
293, -1.062400e-001, 1.202532e-001, 3.400000e-002
294, -1.060619e-001, 1.192669e-001, 3.400000e-002
295, -1.058837e-001, 1.182806e-001, 3.400000e-002
296, -1.057055e-001, 1.172943e-001, 3.400000e-002
297, -1.055273e-001, 1.163080e-001, 3.400000e-002
298, -1.053492e-001, 1.153217e-001, 3.400000e-002
299, -1.051710e-001, 1.143355e-001, 3.400000e-002
300, -1.049928e-001, 1.133492e-001, 3.400000e-002
301, -1.048147e-001, 1.123629e-001, 3.400000e-002
302, -1.046365e-001, 1.113766e-001, 3.400000e-002
303, -1.044583e-001, 1.103903e-001, 3.400000e-002
304, -1.042801e-001, 1.094040e-001, 3.400000e-002
305, -1.041020e-001, 1.084178e-001, 3.400000e-002
306, -1.039238e-001, 1.074315e-001, 3.400000e-002
307, -1.037456e-001, 1.064452e-001, 3.400000e-002
308, -1.035674e-001, 1.054589e-001, 3.400000e-002
309, -1.033893e-001, 1.044726e-001, 3.400000e-002
310, -1.032111e-001, 1.034863e-001, 3.400000e-002
311, -1.030329e-001, 1.025001e-001, 3.400000e-002
312, -1.028548e-001, 1.015138e-001, 3.400000e-002
313, -1.026766e-001, 1.005275e-001, 3.400000e-002
314, -1.024984e-001, 9.954120e-002, 3.400000e-002
315, -1.023202e-001, 9.855492e-002, 3.400000e-002
316, -1.021421e-001, 9.756863e-002, 3.400000e-002
317, -1.019639e-001, 9.658235e-002, 3.400000e-002
318, -1.017857e-001, 9.559607e-002, 3.400000e-002
319, -1.016075e-001, 9.460978e-002, 3.400000e-002
320, -1.014294e-001, 9.362350e-002, 3.400000e-002
321, -1.012512e-001, 9.263721e-002, 3.400000e-002
322, -1.010730e-001, 9.165093e-002, 3.400000e-002
323, -1.008949e-001, 9.066465e-002, 3.400000e-002
324, -1.007167e-001, 8.967836e-002, 3.400000e-002
325, -1.005385e-001, 8.869208e-002, 3.400000e-002
326, -1.003603e-001, 8.770579e-002, 3.400000e-002
327, -1.001822e-001, 8.671951e-002, 3.400000e-002
328, -1.000040e-001, 8.573322e-002, 3.400000e-002
329, -9.982582e-002, 8.474694e-002, 3.400000e-002
330, -9.964765e-002, 8.376066e-002, 3.400000e-002
331, -9.946948e-002, 8.277437e-002, 3.400000e-002
332, -9.929130e-002, 8.178809e-002, 3.400000e-002
333, -9.911313e-002, 8.080180e-002, 3.400000e-002
334, -9.893496e-002, 7.981552e-002, 3.400000e-002
335, -9.875679e-002, 7.882924e-002, 3.400000e-002
336, -9.857861e-002, 7.784295e-002, 3.400000e-002
337, -9.840044e-002, 7.685667e-002, 3.400000e-002
338, -9.822227e-002, 7.587038e-002, 3.400000e-002
339, -9.804410e-002, 7.488410e-002, 3.400000e-002
340, -9.786592e-002, 7.389781e-002, 3.400000e-002
341, -9.768775e-002, 7.291153e-002, 3.400000e-002
342, -9.750958e-002, 7.192525e-002, 3.400000e-002
343, -9.733141e-002, 7.093896e-002, 3.400000e-002
344, -9.715323e-002, 6.995268e-002, 3.400000e-002
345, -9.697506e-002, 6.896639e-002, 3.400000e-002
346, -9.679689e-002, 6.798011e-002, 3.400000e-002
347, -9.661872e-002, 6.699383e-002, 3.400000e-002
348, -9.644054e-002, 6.600754e-002, 3.400000e-002
349, -9.626237e-002, 6.502126e-002, 3.400000e-002
350, -9.608420e-002, 6.403497e-002, 3.400000e-002
351, -9.590603e-002, 6.304869e-002, 3.400000e-002
352, -9.572785e-002, 6.206240e-002, 3.400000e-002
353, -9.554968e-002, 6.107612e-002, 3.400000e-002
354, -9.537151e-002, 6.008984e-002, 3.400000e-002
355, -9.519334e-002, 5.910355e-002, 3.400000e-002
356, -9.501516e-002, 5.811727e-002, 3.400000e-002
357, -9.483699e-002, 5.713098e-002, 3.400000e-002
358, -9.465882e-002, 5.614470e-002, 3.400000e-002
359, -9.448065e-002, 5.515842e-002, 3.400000e-002
360, -9.430247e-002, 5.417213e-002, 3.400000e-002
361, -9.412430e-002, 5.318585e-002, 3.400000e-002
362, -9.394613e-002, 5.219956e-002, 3.400000e-002
363, -9.376795e-002, 5.121328e-002, 3.400000e-002
364, -9.358978e-002, 5.022699e-002, 3.400000e-002
365, -9.341161e-002, 4.924071e-002, 3.400000e-002
366, -9.323344e-002, 4.825443e-002, 3.400000e-002
367, -9.305526e-002, 4.726814e-002, 3.400000e-002
368, -9.287709e-002, 4.628186e-002, 3.400000e-002
369, -9.269892e-002, 4.529557e-002, 3.400000e-002
370, -9.252075e-002, 4.430929e-002, 3.400000e-002
371, -9.234257e-002, 4.332301e-002, 3.400000e-002
372, -9.216440e-002, 4.233672e-002, 3.400000e-002
373, -9.198623e-002, 4.135044e-002, 3.400000e-002
374, -9.180806e-002, 4.036415e-002, 3.400000e-002
375, -9.162988e-002, 3.937787e-002, 3.400000e-002
376, -9.145171e-002, 3.839159e-002, 3.400000e-002
377, -9.127354e-002, 3.740530e-002, 3.400000e-002
378, -9.109537e-002, 3.641902e-002, 3.400000e-002
379, -9.091719e-002, 3.543273e-002, 3.400000e-002
380, -9.073902e-002, 3.444645e-002, 3.400000e-002
381, -9.056085e-002, 3.346016e-002, 3.400000e-002
382, -9.038268e-002, 3.247388e-002, 3.400000e-002
383, -9.020450e-002, 3.148760e-002, 3.400000e-002
384, -9.002633e-002, 3.050131e-002, 3.400000e-002
385, -8.984816e-002, 2.951503e-002, 3.400000e-002
386, -8.966999e-002, 2.852874e-002, 3.400000e-002
387, -8.949181e-002, 2.754246e-002, 3.400000e-002
388, -8.931364e-002, 2.655618e-002, 3.400000e-002
389, -8.913547e-002, 2.556989e-002, 3.400000e-002
390, -8.895730e-002, 2.458361e-002, 3.400000e-002
391, -8.877912e-002, 2.359732e-002, 3.400000e-002
392, -8.860095e-002, 2.261104e-002, 3.400000e-002
393, -8.842278e-002, 2.162475e-002, 3.400000e-002
394, -8.824461e-002, 2.063847e-002, 3.400000e-002
395, -8.806643e-002, 1.965219e-002, 3.400000e-002
396, -8.788826e-002, 1.866590e-002, 3.400000e-002
397, -8.771009e-002, 1.767962e-002, 3.400000e-002
398, -8.753191e-002, 1.669333e-002, 3.400000e-002
399, -8.735374e-002, 1.570705e-002, 3.400000e-002
400, -8.717557e-002, 1.472077e-002, 3.400000e-002
401, -8.699740e-002, 1.373448e-002, 3.400000e-002
402, -8.681922e-002, 1.274820e-002, 3.400000e-002
403, -8.664105e-002, 1.176191e-002, 3.400000e-002
404, -8.646288e-002, 1.077563e-002, 3.400000e-002
405, -8.628471e-002, 9.789345e-003, 3.400000e-002
406, -8.610653e-002, 8.803061e-003, 3.400000e-002
407, -8.592836e-002, 7.816777e-003, 3.400000e-002
408, -1.210004e-001, 2.075151e-001, 2.177162e-002
409, -1.200273e-001, 2.075320e-001, 2.158527e-002
410, -1.190887e-001, 2.074416e-001, 2.128034e-002
411, -1.182104e-001, 2.072462e-001, 2.086514e-002
412, -1.174163e-001, 2.069513e-001, 2.035101e-002
413, -1.167280e-001, 2.065648e-001, 1.975196e-002
414, -1.161642e-001, 2.060974e-001, 1.908434e-002
415, -1.157405e-001, 2.055617e-001, 1.836636e-002
416, -1.154683e-001, 2.049725e-001, 1.761760e-002
417, -1.153551e-001, 2.043456e-001, 1.685849e-002
418, -1.154039e-001, 2.036984e-001, 1.610973e-002
419, -1.156134e-001, 2.030483e-001, 1.539175e-002
420, -1.159780e-001, 2.024132e-001, 1.472412e-002
421, -1.164876e-001, 2.018103e-001, 1.412508e-002
422, -1.171283e-001, 2.012562e-001, 1.361094e-002
423, -1.178828e-001, 2.007659e-001, 1.319575e-002
424, -1.187303e-001, 2.003527e-001, 1.289082e-002
425, -1.196478e-001, 2.000281e-001, 1.270446e-002
426, -1.206103e-001, 1.998008e-001, 1.264178e-002
427, -1.215915e-001, 1.996770e-001, 1.270446e-002
428, -1.225646e-001, 1.996601e-001, 1.289082e-002
429, -1.235032e-001, 1.997505e-001, 1.319575e-002
430, -1.243815e-001, 1.999459e-001, 1.361094e-002
431, -1.251756e-001, 2.002408e-001, 1.412508e-002
432, -1.258639e-001, 2.006273e-001, 1.472412e-002
433, -1.264277e-001, 2.010947e-001, 1.539175e-002
434, -1.268514e-001, 2.016304e-001, 1.610973e-002
435, -1.271236e-001, 2.022196e-001, 1.685849e-002
436, -1.272368e-001, 2.028465e-001, 1.761760e-002
437, -1.271880e-001, 2.034937e-001, 1.836636e-002
438, -1.269785e-001, 2.041438e-001, 1.908434e-002
439, -1.266139e-001, 2.047789e-001, 1.975196e-002
440, -1.261043e-001, 2.053818e-001, 2.035101e-002
441, -1.254636e-001, 2.059359e-001, 2.086514e-002
442, -1.247091e-001, 2.064263e-001, 2.128034e-002
443, -1.238616e-001, 2.068394e-001, 2.158527e-002
444, -1.229441e-001, 2.071640e-001, 2.177162e-002
445, -1.218431e-001, 2.066250e-001, 2.247497e-002
446, -1.217025e-001, 2.058466e-001, 2.310040e-002
447, -1.215598e-001, 2.050564e-001, 2.371037e-002
448, -1.214149e-001, 2.042547e-001, 2.430466e-002
449, -1.212681e-001, 2.034418e-001, 2.488303e-002
450, -1.211193e-001, 2.026181e-001, 2.544529e-002
451, -1.209686e-001, 2.017837e-001, 2.599121e-002
452, -1.208160e-001, 2.009391e-001, 2.652059e-002
453, -1.206616e-001, 2.000846e-001, 2.703324e-002
454, -1.205055e-001, 1.992205e-001, 2.752895e-002
455, -1.203477e-001, 1.983470e-001, 2.800754e-002
456, -1.201883e-001, 1.974646e-001, 2.846884e-002
457, -1.200273e-001, 1.965735e-001, 2.891266e-002
458, -1.198649e-001, 1.956742e-001, 2.933884e-002
459, -1.197010e-001, 1.947669e-001, 2.974721e-002
460, -1.195357e-001, 1.938519e-001, 3.013763e-002
461, -1.193691e-001, 1.929297e-001, 3.050994e-002
462, -1.192012e-001, 1.920006e-001, 3.086401e-002
463, -1.190322e-001, 1.910648e-001, 3.119969e-002
464, -1.188620e-001, 1.901229e-001, 3.151687e-002
465, -1.186908e-001, 1.891750e-001, 3.181543e-002
466, -1.185186e-001, 1.882216e-001, 3.209525e-002
467, -1.183454e-001, 1.872631e-001, 3.235623e-002
468, -1.181714e-001, 1.862998e-001, 3.259827e-002
469, -1.179966e-001, 1.853320e-001, 3.282128e-002
470, -1.178210e-001, 1.843602e-001, 3.302519e-002
471, -1.176448e-001, 1.833847e-001, 3.320991e-002
472, -1.174679e-001, 1.824058e-001, 3.337537e-002
473, -1.172906e-001, 1.814239e-001, 3.352152e-002
474, -1.171127e-001, 1.804395e-001, 3.364830e-002
475, -1.169345e-001, 1.794528e-001, 3.375567e-002
476, -1.167559e-001, 1.784642e-001, 3.384357e-002
477, -1.165770e-001, 1.774742e-001, 3.391198e-002
478, -1.163980e-001, 1.764830e-001, 3.396087e-002
479, -1.162188e-001, 1.754911e-001, 3.399022e-002
480, -1.241338e-001, 2.249222e-001, 6.928552e-003
481, -1.231549e-001, 2.249614e-001, 6.717352e-003
482, -1.222138e-001, 2.248997e-001, 6.378305e-003
483, -1.213341e-001, 2.247268e-001, 5.930404e-003
484, -1.205365e-001, 2.244275e-001, 5.402924e-003
485, -1.198396e-001, 2.239787e-001, 4.840421e-003
486, -1.192616e-001, 2.233556e-001, 4.311493e-003
487, -1.188168e-001, 2.225576e-001, 3.903652e-003
488, -1.184996e-001, 2.216366e-001, 3.672970e-003
489, -1.182815e-001, 2.206607e-001, 3.605527e-003
490, -1.181330e-001, 2.196702e-001, 3.654876e-003
491, -1.180347e-001, 2.186799e-001, 3.781261e-003
492, -1.179762e-001, 2.176942e-001, 3.958609e-003
493, -1.179520e-001, 2.167137e-001, 4.169548e-003
494, -1.179609e-001, 2.157384e-001, 4.404549e-003
495, -1.180032e-001, 2.147682e-001, 4.656710e-003
496, -1.180798e-001, 2.138031e-001, 4.919831e-003
497, -1.181939e-001, 2.128438e-001, 5.190499e-003
498, -1.183501e-001, 2.118917e-001, 5.465497e-003
499, -1.185554e-001, 2.109493e-001, 5.741750e-003
500, -1.188195e-001, 2.100212e-001, 6.015763e-003
501, -1.191565e-001, 2.091150e-001, 6.283004e-003
502, -1.195893e-001, 2.082466e-001, 6.535993e-003
503, -1.201506e-001, 2.074478e-001, 6.761492e-003
504, -1.208851e-001, 2.067912e-001, 6.932112e-003
505, -1.218057e-001, 2.064173e-001, 7.000000e-003
506, -1.227989e-001, 2.064455e-001, 6.932116e-003
507, -1.237166e-001, 2.068038e-001, 6.761445e-003
508, -1.245220e-001, 2.073556e-001, 6.535972e-003
509, -1.252311e-001, 2.080178e-001, 6.282945e-003
510, -1.258640e-001, 2.087487e-001, 6.015727e-003
511, -1.264362e-001, 2.095258e-001, 5.741716e-003
512, -1.269582e-001, 2.103367e-001, 5.465442e-003
513, -1.274382e-001, 2.111736e-001, 5.190346e-003
514, -1.278804e-001, 2.120326e-001, 4.919735e-003
515, -1.282895e-001, 2.129101e-001, 4.656744e-003
516, -1.286683e-001, 2.138044e-001, 4.405121e-003
517, -1.290180e-001, 2.147149e-001, 4.169982e-003
518, -1.293386e-001, 2.156417e-001, 3.958585e-003
519, -1.296287e-001, 2.165856e-001, 3.781267e-003
520, -1.298831e-001, 2.175476e-001, 3.654802e-003
521, -1.300905e-001, 2.185275e-001, 3.605450e-003
522, -1.302277e-001, 2.195180e-001, 3.672995e-003
523, -1.302527e-001, 2.204918e-001, 3.903682e-003
524, -1.301152e-001, 2.213950e-001, 4.311571e-003
525, -1.297920e-001, 2.221812e-001, 4.840210e-003
526, -1.292960e-001, 2.228451e-001, 5.402924e-003
527, -1.286536e-001, 2.234050e-001, 5.930314e-003
528, -1.278899e-001, 2.238744e-001, 6.378324e-003
529, -1.270300e-001, 2.242615e-001, 6.717446e-003
530, -1.260991e-001, 2.245669e-001, 6.928387e-003
531, -1.221182e-001, 2.081477e-001, 2.118934e-002
532, -1.222549e-001, 2.089041e-001, 2.054437e-002
533, -1.223915e-001, 2.096606e-001, 1.989940e-002
534, -1.225282e-001, 2.104170e-001, 1.925443e-002
535, -1.226648e-001, 2.111734e-001, 1.860946e-002
536, -1.228014e-001, 2.119298e-001, 1.796449e-002
537, -1.229381e-001, 2.126862e-001, 1.731952e-002
538, -1.230747e-001, 2.134426e-001, 1.667455e-002
539, -1.232114e-001, 2.141990e-001, 1.602958e-002
540, -1.233480e-001, 2.149554e-001, 1.538461e-002
541, -1.234847e-001, 2.157118e-001, 1.473964e-002
542, -1.236213e-001, 2.164682e-001, 1.409467e-002
543, -1.237580e-001, 2.172246e-001, 1.344970e-002
544, -1.238946e-001, 2.179810e-001, 1.280473e-002
545, -1.240312e-001, 2.187374e-001, 1.215976e-002
546, -1.241679e-001, 2.194938e-001, 1.151479e-002
547, -1.243045e-001, 2.202502e-001, 1.086982e-002
548, -1.244412e-001, 2.210066e-001, 1.022485e-002
549, -1.245778e-001, 2.217630e-001, 9.579880e-003
550, -1.247145e-001, 2.225194e-001, 8.934910e-003
551, -1.248511e-001, 2.232758e-001, 8.289940e-003
552, -1.249878e-001, 2.240322e-001, 7.644970e-003
553, -1.457373e-001, 2.545858e-001, 9.269520e-004
554, -1.452765e-001, 2.539845e-001, 1.600980e-003
555, -1.447446e-001, 2.532828e-001, 2.108920e-003
556, -1.441858e-001, 2.525359e-001, 2.514388e-003
557, -1.436163e-001, 2.517625e-001, 2.849412e-003
558, -1.430437e-001, 2.509700e-001, 3.130521e-003
559, -1.424727e-001, 2.501620e-001, 3.367285e-003
560, -1.419070e-001, 2.493399e-001, 3.565251e-003
561, -1.413498e-001, 2.485043e-001, 3.727425e-003
562, -1.408049e-001, 2.476545e-001, 3.853798e-003
563, -1.402761e-001, 2.467900e-001, 3.943644e-003
564, -1.397687e-001, 2.459097e-001, 3.993153e-003
565, -1.392896e-001, 2.450123e-001, 3.994328e-003
566, -1.388471e-001, 2.440982e-001, 3.937447e-003
567, -1.384528e-001, 2.431702e-001, 3.804467e-003
568, -1.381217e-001, 2.422383e-001, 3.568924e-003
569, -1.378699e-001, 2.413274e-001, 3.195981e-003
570, -1.377083e-001, 2.404882e-001, 2.648170e-003
571, -1.376307e-001, 2.397996e-001, 1.907679e-003
572, -1.376082e-001, 2.393472e-001, 1.001016e-003
573, -1.467808e-001, 2.554553e-001, 0.000000e+000
574, -1.475990e-001, 2.560326e-001, 0.000000e+000
575, -1.484171e-001, 2.566100e-001, 0.000000e+000
576, -1.492353e-001, 2.571873e-001, 0.000000e+000
577, -1.500534e-001, 2.577647e-001, 0.000000e+000
578, -1.508716e-001, 2.583421e-001, 0.000000e+000
579, -1.516897e-001, 2.589194e-001, 0.000000e+000
580, -1.525079e-001, 2.594968e-001, 0.000000e+000
581, -1.533260e-001, 2.600741e-001, 0.000000e+000
582, -1.541442e-001, 2.606515e-001, 0.000000e+000
583, -1.549624e-001, 2.612288e-001, 0.000000e+000
584, -1.557805e-001, 2.618062e-001, 0.000000e+000
585, -1.565987e-001, 2.623835e-001, 0.000000e+000
586, -1.574168e-001, 2.629609e-001, 0.000000e+000
587, -1.582350e-001, 2.635382e-001, 0.000000e+000
588, -1.590531e-001, 2.641156e-001, 0.000000e+000
589, -1.598713e-001, 2.646929e-001, 0.000000e+000
590, -1.606894e-001, 2.652703e-001, 0.000000e+000
591, -1.615076e-001, 2.658476e-001, 0.000000e+000
592, -1.623257e-001, 2.664250e-001, 0.000000e+000
593, -1.631439e-001, 2.670023e-001, 0.000000e+000
594, -1.639621e-001, 2.675797e-001, 0.000000e+000
595, -1.647802e-001, 2.681570e-001, 0.000000e+000
596, -1.655984e-001, 2.687344e-001, 0.000000e+000
597, -1.664165e-001, 2.693117e-001, 0.000000e+000
598, -1.672347e-001, 2.698891e-001, 0.000000e+000
599, -1.680528e-001, 2.704665e-001, 0.000000e+000
600, -1.688710e-001, 2.710438e-001, 0.000000e+000
601, -1.696891e-001, 2.716212e-001, 0.000000e+000
602, -1.705073e-001, 2.721985e-001, 0.000000e+000
603, -1.713254e-001, 2.727759e-001, 0.000000e+000
604, -1.721436e-001, 2.733532e-001, 0.000000e+000
605, -1.729618e-001, 2.739306e-001, 0.000000e+000
606, -1.737799e-001, 2.745079e-001, 0.000000e+000
607, -1.745981e-001, 2.750853e-001, 0.000000e+000
608, -1.754162e-001, 2.756626e-001, 0.000000e+000
609, -1.762344e-001, 2.762400e-001, 0.000000e+000
610, -1.770525e-001, 2.768173e-001, 0.000000e+000
611, -1.778707e-001, 2.773947e-001, 0.000000e+000
612, -1.786888e-001, 2.779720e-001, 0.000000e+000
613, -1.795070e-001, 2.785494e-001, 0.000000e+000
614, -1.803251e-001, 2.791267e-001, 0.000000e+000
615, -1.811433e-001, 2.797041e-001, 0.000000e+000
616, -1.819615e-001, 2.802814e-001, 0.000000e+000
617, -1.827796e-001, 2.808588e-001, 0.000000e+000
618, -1.835978e-001, 2.814361e-001, 0.000000e+000
619, -1.844159e-001, 2.820135e-001, 0.000000e+000
620, -1.852341e-001, 2.825909e-001, 0.000000e+000
621, -1.860522e-001, 2.831682e-001, 0.000000e+000
622, -1.868704e-001, 2.837456e-001, 0.000000e+000
623, -1.876885e-001, 2.843229e-001, 0.000000e+000
624, -1.885067e-001, 2.849003e-001, 0.000000e+000
625, -1.893248e-001, 2.854776e-001, 0.000000e+000
626, -1.901430e-001, 2.860550e-001, 0.000000e+000
627, -1.909612e-001, 2.866323e-001, 0.000000e+000
628, -1.917793e-001, 2.872097e-001, 0.000000e+000
629, -1.925975e-001, 2.877870e-001, 0.000000e+000
630, -1.934156e-001, 2.883644e-001, 0.000000e+000
631, -1.942338e-001, 2.889417e-001, 0.000000e+000
632, -1.950519e-001, 2.895191e-001, 0.000000e+000
633, -1.958701e-001, 2.900964e-001, 0.000000e+000
634, -1.966882e-001, 2.906738e-001, 0.000000e+000
635, -1.975064e-001, 2.912511e-001, 0.000000e+000
636, -1.983245e-001, 2.918285e-001, 0.000000e+000
637, -1.991427e-001, 2.924058e-001, 0.000000e+000
638, -1.999609e-001, 2.929832e-001, 0.000000e+000
639, -2.007790e-001, 2.935605e-001, 0.000000e+000
640, -2.015972e-001, 2.941379e-001, 0.000000e+000
641, -2.024153e-001, 2.947153e-001, 0.000000e+000
642, -2.032335e-001, 2.952926e-001, 0.000000e+000
643, -2.040516e-001, 2.958700e-001, 0.000000e+000
644, -2.048698e-001, 2.964473e-001, 0.000000e+000
645, -2.056879e-001, 2.970247e-001, 0.000000e+000
646, -2.065061e-001, 2.976020e-001, 0.000000e+000
647, -2.073242e-001, 2.981794e-001, 0.000000e+000
648, -2.081424e-001, 2.987567e-001, 0.000000e+000
649, -2.089606e-001, 2.993341e-001, 0.000000e+000
650, -2.097787e-001, 2.999114e-001, 0.000000e+000
651, -2.105969e-001, 3.004888e-001, 0.000000e+000
652, -2.114150e-001, 3.010661e-001, 0.000000e+000
653, -2.122332e-001, 3.016435e-001, 0.000000e+000
654, -2.130513e-001, 3.022208e-001, 0.000000e+000
655, -2.138695e-001, 3.027982e-001, 0.000000e+000
656, -2.146876e-001, 3.033755e-001, 0.000000e+000
657, -2.155058e-001, 3.039529e-001, 0.000000e+000
658, -2.163239e-001, 3.045302e-001, 0.000000e+000
659, -2.171421e-001, 3.051076e-001, 0.000000e+000
660, -2.179603e-001, 3.056850e-001, 0.000000e+000
661, -2.187784e-001, 3.062623e-001, 0.000000e+000
662, -2.195966e-001, 3.068397e-001, 0.000000e+000
663, -2.204147e-001, 3.074170e-001, 0.000000e+000
664, -2.212329e-001, 3.079944e-001, 0.000000e+000
665, -2.220510e-001, 3.085717e-001, 0.000000e+000
666, -2.228692e-001, 3.091491e-001, 0.000000e+000
667, -2.236873e-001, 3.097264e-001, 0.000000e+000
668, -2.245055e-001, 3.103038e-001, 0.000000e+000
669, -2.253236e-001, 3.108811e-001, 0.000000e+000
670, -2.261418e-001, 3.114585e-001, 0.000000e+000
671, -2.269600e-001, 3.120358e-001, 0.000000e+000
672, -2.277781e-001, 3.126132e-001, 0.000000e+000
673, -2.285963e-001, 3.131905e-001, 0.000000e+000
674, -2.294144e-001, 3.137679e-001, 0.000000e+000
675, -2.302326e-001, 3.143452e-001, 0.000000e+000
676, -2.310507e-001, 3.149226e-001, 0.000000e+000
677, -2.318689e-001, 3.154999e-001, 0.000000e+000
678, -2.326870e-001, 3.160773e-001, 0.000000e+000
679, -2.335052e-001, 3.166546e-001, 0.000000e+000
680, -2.343233e-001, 3.172320e-001, 0.000000e+000
681, -2.351415e-001, 3.178094e-001, 0.000000e+000
682, -2.359597e-001, 3.183867e-001, 0.000000e+000
683, -2.367778e-001, 3.189641e-001, 0.000000e+000
684, -2.375960e-001, 3.195414e-001, 0.000000e+000
685, -2.384141e-001, 3.201188e-001, 0.000000e+000
686, -2.392323e-001, 3.206961e-001, 0.000000e+000
687, -2.400504e-001, 3.212735e-001, 0.000000e+000
688, -2.408686e-001, 3.218508e-001, 0.000000e+000
689, -2.416867e-001, 3.224282e-001, 0.000000e+000
690, -2.425049e-001, 3.230055e-001, 0.000000e+000
691, -2.433230e-001, 3.235829e-001, 0.000000e+000
692, -2.441412e-001, 3.241602e-001, 0.000000e+000
693, -2.449594e-001, 3.247376e-001, 0.000000e+000
694, -2.457775e-001, 3.253149e-001, 0.000000e+000
695, -2.465957e-001, 3.258923e-001, 0.000000e+000
696, -2.474138e-001, 3.264696e-001, 0.000000e+000
697, -2.482320e-001, 3.270470e-001, 0.000000e+000
698, -2.452713e-001, 3.153092e-001, 9.593660e-004
699, -2.456058e-001, 3.158796e-001, 1.722509e-003
700, -2.460151e-001, 3.165928e-001, 2.313105e-003
701, -2.464523e-001, 3.173775e-001, 2.781808e-003
702, -2.468967e-001, 3.182062e-001, 3.159502e-003
703, -2.473364e-001, 3.190677e-001, 3.462414e-003
704, -2.477619e-001, 3.199565e-001, 3.699342e-003
705, -2.481636e-001, 3.208710e-001, 3.871467e-003
706, -2.485302e-001, 3.218101e-001, 3.974574e-003
707, -2.488472e-001, 3.227723e-001, 3.997090e-003
708, -2.490957e-001, 3.237510e-001, 3.917368e-003
709, -2.492543e-001, 3.247273e-001, 3.701963e-003
710, -2.493077e-001, 3.256583e-001, 3.310291e-003
711, -2.492654e-001, 3.264748e-001, 2.715936e-003
712, -2.491712e-001, 3.271025e-001, 1.929624e-003
713, -2.490844e-001, 3.274926e-001, 1.001436e-003
714, -2.443107e-001, 3.144885e-001, 0.000000e+000
715, -2.434962e-001, 3.139137e-001, 0.000000e+000
716, -2.426816e-001, 3.133389e-001, 0.000000e+000
717, -2.418671e-001, 3.127641e-001, 0.000000e+000
718, -2.410525e-001, 3.121893e-001, 0.000000e+000
719, -2.402380e-001, 3.116145e-001, 0.000000e+000
720, -2.394235e-001, 3.110397e-001, 0.000000e+000
721, -2.386089e-001, 3.104649e-001, 0.000000e+000
722, -2.377944e-001, 3.098901e-001, 0.000000e+000
723, -2.369798e-001, 3.093153e-001, 0.000000e+000
724, -2.361653e-001, 3.087405e-001, 0.000000e+000
725, -2.353508e-001, 3.081657e-001, 0.000000e+000
726, -2.345362e-001, 3.075909e-001, 0.000000e+000
727, -2.337217e-001, 3.070161e-001, 0.000000e+000
728, -2.329071e-001, 3.064413e-001, 0.000000e+000
729, -2.320926e-001, 3.058665e-001, 0.000000e+000
730, -2.312781e-001, 3.052917e-001, 0.000000e+000
731, -2.304635e-001, 3.047169e-001, 0.000000e+000
732, -2.296490e-001, 3.041420e-001, 0.000000e+000
733, -2.288344e-001, 3.035672e-001, 0.000000e+000
734, -2.280199e-001, 3.029924e-001, 0.000000e+000
735, -2.272054e-001, 3.024176e-001, 0.000000e+000
736, -2.263908e-001, 3.018428e-001, 0.000000e+000
737, -2.255763e-001, 3.012680e-001, 0.000000e+000
738, -2.247617e-001, 3.006932e-001, 0.000000e+000
739, -2.239472e-001, 3.001184e-001, 0.000000e+000
740, -2.231327e-001, 2.995436e-001, 0.000000e+000
741, -2.223181e-001, 2.989688e-001, 0.000000e+000
742, -2.215036e-001, 2.983940e-001, 0.000000e+000
743, -2.206890e-001, 2.978192e-001, 0.000000e+000
744, -2.198745e-001, 2.972444e-001, 0.000000e+000
745, -2.190600e-001, 2.966696e-001, 0.000000e+000
746, -2.182454e-001, 2.960948e-001, 0.000000e+000
747, -2.174309e-001, 2.955200e-001, 0.000000e+000
748, -2.166163e-001, 2.949452e-001, 0.000000e+000
749, -2.158018e-001, 2.943704e-001, 0.000000e+000
750, -2.149873e-001, 2.937956e-001, 0.000000e+000
751, -2.141727e-001, 2.932208e-001, 0.000000e+000
752, -2.133582e-001, 2.926460e-001, 0.000000e+000
753, -2.125436e-001, 2.920712e-001, 0.000000e+000
754, -2.117291e-001, 2.914964e-001, 0.000000e+000
755, -2.109146e-001, 2.909216e-001, 0.000000e+000
756, -2.101000e-001, 2.903468e-001, 0.000000e+000
757, -2.092855e-001, 2.897720e-001, 0.000000e+000
758, -2.084709e-001, 2.891972e-001, 0.000000e+000
759, -2.076564e-001, 2.886224e-001, 0.000000e+000
760, -2.068419e-001, 2.880476e-001, 0.000000e+000
761, -2.060273e-001, 2.874728e-001, 0.000000e+000
762, -2.052128e-001, 2.868980e-001, 0.000000e+000
763, -2.043982e-001, 2.863232e-001, 0.000000e+000
764, -2.035837e-001, 2.857484e-001, 0.000000e+000
765, -2.027692e-001, 2.851736e-001, 0.000000e+000
766, -2.019546e-001, 2.845988e-001, 0.000000e+000
767, -2.011401e-001, 2.840240e-001, 0.000000e+000
768, -2.003255e-001, 2.834492e-001, 0.000000e+000
769, -1.995110e-001, 2.828744e-001, 0.000000e+000
770, -1.986965e-001, 2.822996e-001, 0.000000e+000
771, -1.978819e-001, 2.817248e-001, 0.000000e+000
772, -1.970674e-001, 2.811500e-001, 0.000000e+000
773, -1.962528e-001, 2.805752e-001, 0.000000e+000
774, -1.954383e-001, 2.800004e-001, 0.000000e+000
775, -1.946238e-001, 2.794256e-001, 0.000000e+000
776, -1.938092e-001, 2.788508e-001, 0.000000e+000
777, -1.929947e-001, 2.782760e-001, 0.000000e+000
778, -1.921801e-001, 2.777012e-001, 0.000000e+000
779, -1.913656e-001, 2.771264e-001, 0.000000e+000
780, -1.905510e-001, 2.765516e-001, 0.000000e+000
781, -1.897365e-001, 2.759768e-001, 0.000000e+000
782, -1.889220e-001, 2.754020e-001, 0.000000e+000
783, -1.881074e-001, 2.748272e-001, 0.000000e+000
784, -1.872929e-001, 2.742524e-001, 0.000000e+000
785, -1.864783e-001, 2.736776e-001, 0.000000e+000
786, -1.856638e-001, 2.731028e-001, 0.000000e+000
787, -1.848493e-001, 2.725280e-001, 0.000000e+000
788, -1.840347e-001, 2.719531e-001, 0.000000e+000
789, -1.832202e-001, 2.713783e-001, 0.000000e+000
790, -1.824056e-001, 2.708035e-001, 0.000000e+000
791, -1.815911e-001, 2.702287e-001, 0.000000e+000
792, -1.807766e-001, 2.696539e-001, 0.000000e+000
793, -1.799620e-001, 2.690791e-001, 0.000000e+000
794, -1.791475e-001, 2.685043e-001, 0.000000e+000
795, -1.783329e-001, 2.679295e-001, 0.000000e+000
796, -1.775184e-001, 2.673547e-001, 0.000000e+000
797, -1.767039e-001, 2.667799e-001, 0.000000e+000
798, -1.758893e-001, 2.662051e-001, 0.000000e+000
799, -1.750748e-001, 2.656303e-001, 0.000000e+000
800, -1.742602e-001, 2.650555e-001, 0.000000e+000
801, -1.734457e-001, 2.644807e-001, 0.000000e+000
802, -1.726312e-001, 2.639059e-001, 0.000000e+000
803, -1.718166e-001, 2.633311e-001, 0.000000e+000
804, -1.710021e-001, 2.627563e-001, 0.000000e+000
805, -1.701875e-001, 2.621815e-001, 0.000000e+000
806, -1.693730e-001, 2.616067e-001, 0.000000e+000
807, -1.685585e-001, 2.610319e-001, 0.000000e+000
808, -1.677439e-001, 2.604571e-001, 0.000000e+000
809, -1.669294e-001, 2.598823e-001, 0.000000e+000
810, -1.661148e-001, 2.593075e-001, 0.000000e+000
811, -1.653003e-001, 2.587327e-001, 0.000000e+000
812, -1.644858e-001, 2.581579e-001, 0.000000e+000
813, -1.636712e-001, 2.575831e-001, 0.000000e+000
814, -1.628567e-001, 2.570083e-001, 0.000000e+000
815, -1.620421e-001, 2.564335e-001, 0.000000e+000
816, -1.612276e-001, 2.558587e-001, 0.000000e+000
817, -1.604131e-001, 2.552839e-001, 0.000000e+000
818, -1.595985e-001, 2.547091e-001, 0.000000e+000
819, -1.587840e-001, 2.541343e-001, 0.000000e+000
820, -1.579694e-001, 2.535595e-001, 0.000000e+000
821, -1.571549e-001, 2.529847e-001, 0.000000e+000
822, -1.563404e-001, 2.524099e-001, 0.000000e+000
823, -1.555258e-001, 2.518351e-001, 0.000000e+000
824, -1.547113e-001, 2.512603e-001, 0.000000e+000
825, -1.538967e-001, 2.506855e-001, 0.000000e+000
826, -1.530822e-001, 2.501107e-001, 0.000000e+000
827, -1.522677e-001, 2.495359e-001, 0.000000e+000
828, -1.514531e-001, 2.489611e-001, 0.000000e+000
829, -1.506386e-001, 2.483863e-001, 0.000000e+000
830, -1.498240e-001, 2.478115e-001, 0.000000e+000
831, -1.490095e-001, 2.472367e-001, 0.000000e+000
832, -1.481950e-001, 2.466619e-001, 0.000000e+000
833, -1.473804e-001, 2.460871e-001, 0.000000e+000
834, -1.465659e-001, 2.455123e-001, 0.000000e+000
835, -1.457513e-001, 2.449375e-001, 0.000000e+000
836, -1.449368e-001, 2.443627e-001, 0.000000e+000
837, -1.441223e-001, 2.437879e-001, 0.000000e+000
838, -1.433077e-001, 2.432131e-001, 0.000000e+000
839, -1.424932e-001, 2.426383e-001, 0.000000e+000
840, -1.416786e-001, 2.420635e-001, 0.000000e+000
841, -1.408641e-001, 2.414887e-001, 0.000000e+000
842, -1.400496e-001, 2.409139e-001, 0.000000e+000
843, -1.392350e-001, 2.403390e-001, 0.000000e+000
844, -1.384205e-001, 2.397642e-001, 0.000000e+000
845, -1.355927e-001, 2.355046e-001, 9.849066e-004
846, -1.352516e-001, 2.352296e-001, 1.882134e-003
847, -1.347654e-001, 2.348035e-001, 2.644254e-003
848, -1.342052e-001, 2.342435e-001, 3.254350e-003
849, -1.336369e-001, 2.335522e-001, 3.699669e-003
850, -1.331324e-001, 2.327288e-001, 3.954446e-003
851, -1.327712e-001, 2.317994e-001, 3.981355e-003
852, -1.325988e-001, 2.308414e-001, 3.762438e-003
853, -1.325890e-001, 2.299459e-001, 3.320173e-003
854, -1.326752e-001, 2.291749e-001, 2.690297e-003
855, -1.327932e-001, 2.285720e-001, 1.902202e-003
856, -1.328900e-001, 2.281811e-001, 9.882347e-004
857, -1.366901e-001, 2.353670e-001, 0.000000e+000
858, -1.376625e-001, 2.351327e-001, 0.000000e+000
859, -1.386350e-001, 2.348985e-001, 0.000000e+000
860, -1.396074e-001, 2.346642e-001, 0.000000e+000
861, -1.405799e-001, 2.344299e-001, 0.000000e+000
862, -1.415523e-001, 2.341957e-001, 0.000000e+000
863, -1.425248e-001, 2.339614e-001, 0.000000e+000
864, -1.434972e-001, 2.337271e-001, 0.000000e+000
865, -1.444697e-001, 2.334929e-001, 0.000000e+000
866, -1.454421e-001, 2.332586e-001, 0.000000e+000
867, -1.464146e-001, 2.330243e-001, 0.000000e+000
868, -1.473870e-001, 2.327901e-001, 0.000000e+000
869, -1.483595e-001, 2.325558e-001, 0.000000e+000
870, -1.493319e-001, 2.323215e-001, 0.000000e+000
871, -1.503044e-001, 2.320873e-001, 0.000000e+000
872, -1.512768e-001, 2.318530e-001, 0.000000e+000
873, -1.522493e-001, 2.316187e-001, 0.000000e+000
874, -1.532217e-001, 2.313845e-001, 0.000000e+000
875, -1.541942e-001, 2.311502e-001, 0.000000e+000
876, -1.551666e-001, 2.309159e-001, 0.000000e+000
877, -1.561391e-001, 2.306817e-001, 0.000000e+000
878, -1.571115e-001, 2.304474e-001, 0.000000e+000
879, -1.580840e-001, 2.302131e-001, 0.000000e+000
880, -1.590564e-001, 2.299788e-001, 0.000000e+000
881, -1.600288e-001, 2.297446e-001, 0.000000e+000
882, -1.610013e-001, 2.295103e-001, 0.000000e+000
883, -1.619737e-001, 2.292760e-001, 0.000000e+000
884, -1.629462e-001, 2.290418e-001, 0.000000e+000
885, -1.639186e-001, 2.288075e-001, 0.000000e+000
886, -1.648911e-001, 2.285732e-001, 0.000000e+000
887, -1.658635e-001, 2.283390e-001, 0.000000e+000
888, -1.668360e-001, 2.281047e-001, 0.000000e+000
889, -1.678084e-001, 2.278704e-001, 0.000000e+000
890, -1.687809e-001, 2.276362e-001, 0.000000e+000
891, -1.697533e-001, 2.274019e-001, 0.000000e+000
892, -1.707258e-001, 2.271676e-001, 0.000000e+000
893, -1.716982e-001, 2.269334e-001, 0.000000e+000
894, -1.726707e-001, 2.266991e-001, 0.000000e+000
895, -1.736431e-001, 2.264648e-001, 0.000000e+000
896, -1.746156e-001, 2.262306e-001, 0.000000e+000
897, -1.755880e-001, 2.259963e-001, 0.000000e+000
898, -1.765605e-001, 2.257620e-001, 0.000000e+000
899, -1.775329e-001, 2.255278e-001, 0.000000e+000
900, -1.785054e-001, 2.252935e-001, 0.000000e+000
901, -1.794778e-001, 2.250592e-001, 0.000000e+000
902, -1.804503e-001, 2.248249e-001, 0.000000e+000
903, -1.814227e-001, 2.245907e-001, 0.000000e+000
904, -1.823952e-001, 2.243564e-001, 0.000000e+000
905, -1.833676e-001, 2.241221e-001, 0.000000e+000
906, -1.843401e-001, 2.238879e-001, 0.000000e+000
907, -1.853125e-001, 2.236536e-001, 0.000000e+000
908, -1.862850e-001, 2.234193e-001, 0.000000e+000
909, -1.872574e-001, 2.231851e-001, 0.000000e+000
910, -1.882299e-001, 2.229508e-001, 0.000000e+000
911, -1.892023e-001, 2.227165e-001, 0.000000e+000
912, -1.901748e-001, 2.224823e-001, 0.000000e+000
913, -1.911472e-001, 2.222480e-001, 0.000000e+000
914, -1.921197e-001, 2.220137e-001, 0.000000e+000
915, -1.930921e-001, 2.217795e-001, 0.000000e+000
916, -1.940646e-001, 2.215452e-001, 0.000000e+000
917, -1.950370e-001, 2.213109e-001, 0.000000e+000
918, -1.960094e-001, 2.210767e-001, 0.000000e+000
919, -1.969819e-001, 2.208424e-001, 0.000000e+000
920, -1.979543e-001, 2.206081e-001, 0.000000e+000
921, -1.989268e-001, 2.203738e-001, 0.000000e+000
922, -1.998992e-001, 2.201396e-001, 0.000000e+000
923, -2.008717e-001, 2.199053e-001, 0.000000e+000
924, -2.018441e-001, 2.196710e-001, 0.000000e+000
925, -2.028166e-001, 2.194368e-001, 0.000000e+000
926, -2.037890e-001, 2.192025e-001, 0.000000e+000
927, -2.047615e-001, 2.189682e-001, 0.000000e+000
928, -2.057339e-001, 2.187340e-001, 0.000000e+000
929, -2.067064e-001, 2.184997e-001, 0.000000e+000
930, -2.076788e-001, 2.182654e-001, 0.000000e+000
931, -2.086513e-001, 2.180312e-001, 0.000000e+000
932, -2.096237e-001, 2.177969e-001, 0.000000e+000
933, -2.105962e-001, 2.175626e-001, 0.000000e+000
934, -2.115686e-001, 2.173284e-001, 0.000000e+000
935, -2.125411e-001, 2.170941e-001, 0.000000e+000
936, -2.135135e-001, 2.168598e-001, 0.000000e+000
937, -2.132728e-001, 2.088130e-001, 9.745310e-004
938, -2.134914e-001, 2.091205e-001, 1.882808e-003
939, -2.138137e-001, 2.096114e-001, 2.672125e-003
940, -2.141875e-001, 2.102655e-001, 3.305068e-003
941, -2.145500e-001, 2.110642e-001, 3.750086e-003
942, -2.148322e-001, 2.119782e-001, 3.976104e-003
943, -2.149808e-001, 2.129496e-001, 3.962968e-003
944, -2.149915e-001, 2.139024e-001, 3.719692e-003
945, -2.149029e-001, 2.147750e-001, 3.273626e-003
946, -2.147660e-001, 2.155248e-001, 2.651010e-003
947, -2.146268e-001, 2.161121e-001, 1.874036e-003
948, -2.145239e-001, 2.164928e-001, 9.732018e-004
949, -2.122281e-001, 2.089406e-001, 0.000000e+000
950, -2.112610e-001, 2.091736e-001, 0.000000e+000
951, -2.102939e-001, 2.094066e-001, 0.000000e+000
952, -2.093268e-001, 2.096396e-001, 0.000000e+000
953, -2.083598e-001, 2.098725e-001, 0.000000e+000
954, -2.073927e-001, 2.101055e-001, 0.000000e+000
955, -2.064256e-001, 2.103385e-001, 0.000000e+000
956, -2.054585e-001, 2.105715e-001, 0.000000e+000
957, -2.044914e-001, 2.108044e-001, 0.000000e+000
958, -2.035243e-001, 2.110374e-001, 0.000000e+000
959, -2.025573e-001, 2.112704e-001, 0.000000e+000
960, -2.015902e-001, 2.115034e-001, 0.000000e+000
961, -2.006231e-001, 2.117363e-001, 0.000000e+000
962, -1.996560e-001, 2.119693e-001, 0.000000e+000
963, -1.986889e-001, 2.122023e-001, 0.000000e+000
964, -1.977218e-001, 2.124353e-001, 0.000000e+000
965, -1.967548e-001, 2.126682e-001, 0.000000e+000
966, -1.957877e-001, 2.129012e-001, 0.000000e+000
967, -1.948206e-001, 2.131342e-001, 0.000000e+000
968, -1.938535e-001, 2.133672e-001, 0.000000e+000
969, -1.928864e-001, 2.136001e-001, 0.000000e+000
970, -1.919193e-001, 2.138331e-001, 0.000000e+000
971, -1.909523e-001, 2.140661e-001, 0.000000e+000
972, -1.899852e-001, 2.142991e-001, 0.000000e+000
973, -1.890181e-001, 2.145320e-001, 0.000000e+000
974, -1.880510e-001, 2.147650e-001, 0.000000e+000
975, -1.870839e-001, 2.149980e-001, 0.000000e+000
976, -1.861168e-001, 2.152310e-001, 0.000000e+000
977, -1.851498e-001, 2.154639e-001, 0.000000e+000
978, -1.841827e-001, 2.156969e-001, 0.000000e+000
979, -1.832156e-001, 2.159299e-001, 0.000000e+000
980, -1.822485e-001, 2.161629e-001, 0.000000e+000
981, -1.812814e-001, 2.163958e-001, 0.000000e+000
982, -1.803144e-001, 2.166288e-001, 0.000000e+000
983, -1.793473e-001, 2.168618e-001, 0.000000e+000
984, -1.783802e-001, 2.170948e-001, 0.000000e+000
985, -1.774131e-001, 2.173277e-001, 0.000000e+000
986, -1.764460e-001, 2.175607e-001, 0.000000e+000
987, -1.754789e-001, 2.177937e-001, 0.000000e+000
988, -1.745119e-001, 2.180267e-001, 0.000000e+000
989, -1.735448e-001, 2.182597e-001, 0.000000e+000
990, -1.725777e-001, 2.184926e-001, 0.000000e+000
991, -1.716106e-001, 2.187256e-001, 0.000000e+000
992, -1.706435e-001, 2.189586e-001, 0.000000e+000
993, -1.696764e-001, 2.191916e-001, 0.000000e+000
994, -1.687094e-001, 2.194245e-001, 0.000000e+000
995, -1.677423e-001, 2.196575e-001, 0.000000e+000
996, -1.667752e-001, 2.198905e-001, 0.000000e+000
997, -1.658081e-001, 2.201235e-001, 0.000000e+000
998, -1.648410e-001, 2.203564e-001, 0.000000e+000
999, -1.638739e-001, 2.205894e-001, 0.000000e+000
1000, -1.629069e-001, 2.208224e-001, 0.000000e+000
1001, -1.619398e-001, 2.210554e-001, 0.000000e+000
1002, -1.609727e-001, 2.212883e-001, 0.000000e+000
1003, -1.600056e-001, 2.215213e-001, 0.000000e+000
1004, -1.590385e-001, 2.217543e-001, 0.000000e+000
1005, -1.580714e-001, 2.219873e-001, 0.000000e+000
1006, -1.571044e-001, 2.222202e-001, 0.000000e+000
1007, -1.561373e-001, 2.224532e-001, 0.000000e+000
1008, -1.551702e-001, 2.226862e-001, 0.000000e+000
1009, -1.542031e-001, 2.229192e-001, 0.000000e+000
1010, -1.532360e-001, 2.231521e-001, 0.000000e+000
1011, -1.522689e-001, 2.233851e-001, 0.000000e+000
1012, -1.513019e-001, 2.236181e-001, 0.000000e+000
1013, -1.503348e-001, 2.238511e-001, 0.000000e+000
1014, -1.493677e-001, 2.240840e-001, 0.000000e+000
1015, -1.484006e-001, 2.243170e-001, 0.000000e+000
1016, -1.474335e-001, 2.245500e-001, 0.000000e+000
1017, -1.464664e-001, 2.247830e-001, 0.000000e+000
1018, -1.454994e-001, 2.250159e-001, 0.000000e+000
1019, -1.445323e-001, 2.252489e-001, 0.000000e+000
1020, -1.435652e-001, 2.254819e-001, 0.000000e+000
1021, -1.425981e-001, 2.257149e-001, 0.000000e+000
1022, -1.416310e-001, 2.259478e-001, 0.000000e+000
1023, -1.406640e-001, 2.261808e-001, 0.000000e+000
1024, -1.396969e-001, 2.264138e-001, 0.000000e+000
1025, -1.387298e-001, 2.266468e-001, 0.000000e+000
1026, -1.377627e-001, 2.268797e-001, 0.000000e+000
1027, -1.367956e-001, 2.271127e-001, 0.000000e+000
1028, -1.358285e-001, 2.273457e-001, 0.000000e+000
1029, -1.348615e-001, 2.275787e-001, 0.000000e+000
1030, -1.338944e-001, 2.278117e-001, 0.000000e+000
1031, -1.154881e-001, 2.051975e-001, 0.000000e+000
1032, -1.164722e-001, 2.050198e-001, 0.000000e+000
1033, -1.174563e-001, 2.048420e-001, 0.000000e+000
1034, -1.184404e-001, 2.046642e-001, 0.000000e+000
1035, -1.194244e-001, 2.044864e-001, 0.000000e+000
1036, -1.204085e-001, 2.043087e-001, 0.000000e+000
1037, -1.213926e-001, 2.041309e-001, 0.000000e+000
1038, -1.223766e-001, 2.039531e-001, 0.000000e+000
1039, -1.233607e-001, 2.037754e-001, 0.000000e+000
1040, -1.243448e-001, 2.035976e-001, 0.000000e+000
1041, -1.253289e-001, 2.034198e-001, 0.000000e+000
1042, -1.263129e-001, 2.032420e-001, 0.000000e+000
1043, -1.272970e-001, 2.030643e-001, 0.000000e+000
1044, -1.282106e-001, 2.028992e-001, 9.961416e-004
1045, -1.280018e-001, 2.029369e-001, 1.972064e-003
1046, -1.276585e-001, 2.029989e-001, 2.907879e-003
1047, -1.271872e-001, 2.030841e-001, 3.784253e-003
1048, -1.265984e-001, 2.031905e-001, 4.583935e-003
1049, -1.259035e-001, 2.033160e-001, 5.290124e-003
1050, -1.251166e-001, 2.034582e-001, 5.888419e-003
1051, -1.242541e-001, 2.036140e-001, 6.367385e-003
1052, -1.233332e-001, 2.037803e-001, 6.716187e-003
1053, -1.223728e-001, 2.039538e-001, 6.928385e-003
1054, -1.213926e-001, 2.041309e-001, 7.000000e-003
1055, -1.204123e-001, 2.043080e-001, 6.928385e-003
1056, -1.194519e-001, 2.044815e-001, 6.716187e-003
1057, -1.185310e-001, 2.046478e-001, 6.367385e-003
1058, -1.176686e-001, 2.048036e-001, 5.888419e-003
1059, -1.168817e-001, 2.049458e-001, 5.290124e-003
1060, -1.161867e-001, 2.050713e-001, 4.583935e-003
1061, -1.155979e-001, 2.051777e-001, 3.784253e-003
1062, -1.151266e-001, 2.052628e-001, 2.907879e-003
1063, -1.147834e-001, 2.053249e-001, 1.972064e-003
1064, -1.145745e-001, 2.053626e-001, 9.961416e-004
1065, -1.454984e-001, 2.540064e-001, 0.000000e+000
1066, -1.450341e-001, 2.531348e-001, 0.000000e+000
1067, -1.445699e-001, 2.522632e-001, 0.000000e+000
1068, -1.441056e-001, 2.513916e-001, 0.000000e+000
1069, -1.436413e-001, 2.505200e-001, 0.000000e+000
1070, -1.431771e-001, 2.496484e-001, 0.000000e+000
1071, -1.427128e-001, 2.487769e-001, 0.000000e+000
1072, -1.422486e-001, 2.479053e-001, 0.000000e+000
1073, -1.417843e-001, 2.470337e-001, 0.000000e+000
1074, -1.413200e-001, 2.461621e-001, 0.000000e+000
1075, -1.408558e-001, 2.452905e-001, 0.000000e+000
1076, -1.403915e-001, 2.444189e-001, 0.000000e+000
1077, -1.399273e-001, 2.435474e-001, 0.000000e+000
1078, -1.394630e-001, 2.426758e-001, 0.000000e+000
1079, -1.389987e-001, 2.418042e-001, 0.000000e+000
1080, -1.385345e-001, 2.409326e-001, 0.000000e+000
1081, -1.380702e-001, 2.400610e-001, 0.000000e+000
1082, -1.352841e-001, 2.346905e-001, 0.000000e+000
1083, -1.348743e-001, 2.337688e-001, 0.000000e+000
1084, -1.344885e-001, 2.328368e-001, 0.000000e+000
1085, -1.341268e-001, 2.318952e-001, 0.000000e+000
1086, -1.337897e-001, 2.309445e-001, 0.000000e+000
1087, -1.334773e-001, 2.299854e-001, 0.000000e+000
1088, -1.331897e-001, 2.290186e-001, 0.000000e+000
1089, -1.300906e-001, 2.185283e-001, 3.605602e-003
1090, -1.274389e-001, 2.111763e-001, 5.189721e-003
1091, -1.252241e-001, 2.080107e-001, 6.285622e-003
1092, -1.245268e-001, 2.073596e-001, 6.534395e-003
1093, -1.237157e-001, 2.068033e-001, 6.761643e-003
1094, -1.208857e-001, 2.067908e-001, 6.932215e-003
1095, -1.179613e-001, 2.157415e-001, 4.404402e-003
1096, -1.179523e-001, 2.167140e-001, 4.169987e-003
1097, -1.180348e-001, 2.186809e-001, 3.781363e-003
1098, -1.184999e-001, 2.216370e-001, 3.673335e-003
1099, -1.371676e-001, 2.383666e-001, 0.000000e+000
1100, -1.367293e-001, 2.375437e-001, 0.000000e+000
1101, -1.239975e-001, 2.432691e-001, 9.962039e-004
1102, -1.241849e-001, 2.431693e-001, 1.972128e-003
1103, -1.244929e-001, 2.430052e-001, 2.907905e-003
1104, -1.249154e-001, 2.427802e-001, 3.784486e-003
1105, -1.254436e-001, 2.424988e-001, 4.584025e-003
1106, -1.260669e-001, 2.421668e-001, 5.290247e-003
1107, -1.267726e-001, 2.417909e-001, 5.888775e-003
1108, -1.275463e-001, 2.413788e-001, 6.367424e-003
1109, -1.283722e-001, 2.409389e-001, 6.716451e-003
1110, -1.292335e-001, 2.404800e-001, 6.928750e-003
1111, -1.301128e-001, 2.400117e-001, 7.000000e-003
1112, -1.309920e-001, 2.395434e-001, 6.928750e-003
1113, -1.318534e-001, 2.390845e-001, 6.716451e-003
1114, -1.326793e-001, 2.386446e-001, 6.367424e-003
1115, -1.334530e-001, 2.382325e-001, 5.888775e-003
1116, -1.341586e-001, 2.378566e-001, 5.290247e-003
1117, -1.347820e-001, 2.375246e-001, 4.584025e-003
1118, -1.353102e-001, 2.372432e-001, 3.784486e-003
1119, -1.357327e-001, 2.370182e-001, 2.907905e-003
1120, -1.360407e-001, 2.368541e-001, 1.972128e-003
1121, -1.362281e-001, 2.367543e-001, 9.962039e-004
1122, -1.244056e-001, 2.441867e-001, 0.000000e+000
1123, -1.248765e-001, 2.450709e-001, 0.000000e+000
1124, -1.253475e-001, 2.459550e-001, 0.000000e+000
1125, -1.258184e-001, 2.468392e-001, 0.000000e+000
1126, -1.262894e-001, 2.477233e-001, 0.000000e+000
1127, -1.267603e-001, 2.486075e-001, 0.000000e+000
1128, -1.272313e-001, 2.494916e-001, 0.000000e+000
1129, -1.277022e-001, 2.503757e-001, 0.000000e+000
1130, -1.281732e-001, 2.512599e-001, 0.000000e+000
1131, -1.286441e-001, 2.521440e-001, 0.000000e+000
1132, -1.291151e-001, 2.530282e-001, 0.000000e+000
1133, -1.295860e-001, 2.539123e-001, 0.000000e+000
1134, -1.300570e-001, 2.547964e-001, 0.000000e+000
1135, -1.305279e-001, 2.556806e-001, 0.000000e+000
1136, -1.309989e-001, 2.565647e-001, 0.000000e+000
1137, -1.314698e-001, 2.574489e-001, 0.000000e+000
1138, -1.319408e-001, 2.583330e-001, 0.000000e+000
1139, -1.324117e-001, 2.592172e-001, 0.000000e+000
1140, -1.328827e-001, 2.601013e-001, 0.000000e+000
1141, -1.333536e-001, 2.609854e-001, 0.000000e+000
1142, -1.338246e-001, 2.618696e-001, 0.000000e+000
1143, -1.342955e-001, 2.627537e-001, 0.000000e+000
1144, -1.347665e-001, 2.636379e-001, 0.000000e+000
1145, -1.352374e-001, 2.645220e-001, 0.000000e+000
1146, -1.357084e-001, 2.654061e-001, 0.000000e+000
1147, -1.361793e-001, 2.662903e-001, 0.000000e+000
1148, -1.366503e-001, 2.671744e-001, 0.000000e+000
1149, -1.371212e-001, 2.680586e-001, 0.000000e+000
1150, -1.375922e-001, 2.689427e-001, 0.000000e+000
1151, -1.380632e-001, 2.698268e-001, 0.000000e+000
1152, -1.385341e-001, 2.707110e-001, 0.000000e+000
1153, -1.390051e-001, 2.715951e-001, 0.000000e+000
1154, -1.394760e-001, 2.724793e-001, 0.000000e+000
1155, -1.399470e-001, 2.733634e-001, 0.000000e+000
1156, -1.404179e-001, 2.742476e-001, 0.000000e+000
1157, -1.408889e-001, 2.751317e-001, 0.000000e+000
1158, -1.413598e-001, 2.760158e-001, 0.000000e+000
1159, -1.418308e-001, 2.769000e-001, 0.000000e+000
1160, -1.423017e-001, 2.777841e-001, 0.000000e+000
1161, -1.427727e-001, 2.786683e-001, 0.000000e+000
1162, -1.432436e-001, 2.795524e-001, 0.000000e+000
1163, -1.437146e-001, 2.804365e-001, 0.000000e+000
1164, -1.441855e-001, 2.813207e-001, 0.000000e+000
1165, -1.446565e-001, 2.822048e-001, 0.000000e+000
1166, -1.451274e-001, 2.830890e-001, 0.000000e+000
1167, -1.455984e-001, 2.839731e-001, 0.000000e+000
1168, -1.460693e-001, 2.848573e-001, 0.000000e+000
1169, -1.465403e-001, 2.857414e-001, 0.000000e+000
1170, -1.470112e-001, 2.866255e-001, 0.000000e+000
1171, -1.474822e-001, 2.875097e-001, 0.000000e+000
1172, -1.479531e-001, 2.883938e-001, 0.000000e+000
1173, -1.484241e-001, 2.892780e-001, 0.000000e+000
1174, -1.488950e-001, 2.901621e-001, 0.000000e+000
1175, -1.493660e-001, 2.910462e-001, 0.000000e+000
1176, -1.498369e-001, 2.919304e-001, 0.000000e+000
1177, -1.503079e-001, 2.928145e-001, 0.000000e+000
1178, -1.507788e-001, 2.936987e-001, 0.000000e+000
1179, -1.512498e-001, 2.945828e-001, 0.000000e+000
1180, -1.517207e-001, 2.954670e-001, 0.000000e+000
1181, -1.521917e-001, 2.963511e-001, 0.000000e+000
1182, -1.526626e-001, 2.972352e-001, 0.000000e+000
1183, -1.531336e-001, 2.981194e-001, 0.000000e+000
1184, -1.536045e-001, 2.990035e-001, 0.000000e+000
1185, -1.540755e-001, 2.998877e-001, 0.000000e+000
1186, -1.545464e-001, 3.007718e-001, 0.000000e+000
1187, -1.550174e-001, 3.016559e-001, 0.000000e+000
1188, -1.554883e-001, 3.025401e-001, 0.000000e+000
1189, -1.559593e-001, 3.034242e-001, 0.000000e+000
1190, -1.564303e-001, 3.043084e-001, 0.000000e+000
1191, -1.569012e-001, 3.051925e-001, 0.000000e+000
1192, -1.573722e-001, 3.060766e-001, 0.000000e+000
1193, -1.578431e-001, 3.069608e-001, 0.000000e+000
1194, -1.583141e-001, 3.078449e-001, 0.000000e+000
1195, -1.587850e-001, 3.087291e-001, 0.000000e+000
1196, -1.592560e-001, 3.096132e-001, 0.000000e+000
1197, -1.597269e-001, 3.104974e-001, 0.000000e+000
1198, -1.601979e-001, 3.113815e-001, 0.000000e+000
1199, -1.606688e-001, 3.122656e-001, 0.000000e+000
1200, -1.611398e-001, 3.131498e-001, 0.000000e+000
1201, -1.616107e-001, 3.140339e-001, 0.000000e+000
1202, -1.620817e-001, 3.149181e-001, 0.000000e+000
1203, -1.625526e-001, 3.158022e-001, 0.000000e+000
1204, -1.630236e-001, 3.166863e-001, 0.000000e+000
1205, -1.634945e-001, 3.175705e-001, 0.000000e+000
1206, -1.639655e-001, 3.184546e-001, 0.000000e+000
1207, -1.644364e-001, 3.193388e-001, 0.000000e+000
1208, -1.649074e-001, 3.202229e-001, 0.000000e+000
1209, -1.653783e-001, 3.211071e-001, 0.000000e+000
1210, -1.658493e-001, 3.219912e-001, 0.000000e+000
1211, -1.663202e-001, 3.228753e-001, 0.000000e+000
1212, -1.667912e-001, 3.237595e-001, 0.000000e+000
1213, -1.672621e-001, 3.246436e-001, 0.000000e+000
1214, -1.677331e-001, 3.255278e-001, 0.000000e+000
1215, -1.682040e-001, 3.264119e-001, 0.000000e+000
1216, -1.686750e-001, 3.272960e-001, 0.000000e+000
1217, -1.691459e-001, 3.281802e-001, 0.000000e+000
1218, -1.696169e-001, 3.290643e-001, 0.000000e+000
1219, -1.700878e-001, 3.299485e-001, 0.000000e+000
1220, -1.705588e-001, 3.308326e-001, 0.000000e+000
1221, -1.710297e-001, 3.317168e-001, 0.000000e+000
1222, -1.715007e-001, 3.326009e-001, 0.000000e+000
1223, -1.719716e-001, 3.334850e-001, 0.000000e+000
1224, -1.724426e-001, 3.343692e-001, 0.000000e+000
1225, -1.729135e-001, 3.352533e-001, 0.000000e+000
1226, -1.733845e-001, 3.361375e-001, 0.000000e+000
1227, -1.738555e-001, 3.370216e-001, 0.000000e+000
1228, -1.743264e-001, 3.379057e-001, 0.000000e+000
1229, -1.747974e-001, 3.387899e-001, 0.000000e+000
1230, -1.752683e-001, 3.396740e-001, 0.000000e+000
1231, -1.757393e-001, 3.405582e-001, 0.000000e+000
1232, -1.762102e-001, 3.414423e-001, 0.000000e+000
1233, -1.766812e-001, 3.423265e-001, 0.000000e+000
1234, -1.771521e-001, 3.432106e-001, 0.000000e+000
1235, -1.776231e-001, 3.440947e-001, 0.000000e+000
1236, -1.780940e-001, 3.449789e-001, 0.000000e+000
1237, -1.785650e-001, 3.458630e-001, 0.000000e+000
1238, -1.790359e-001, 3.467472e-001, 0.000000e+000
1239, -1.795069e-001, 3.476313e-001, 0.000000e+000
1240, -1.799778e-001, 3.485154e-001, 0.000000e+000
1241, -1.804488e-001, 3.493996e-001, 0.000000e+000
1242, -1.809197e-001, 3.502837e-001, 0.000000e+000
1243, -1.813907e-001, 3.511679e-001, 0.000000e+000
1244, -1.818616e-001, 3.520520e-001, 0.000000e+000
1245, -1.823326e-001, 3.529361e-001, 0.000000e+000
1246, -1.828035e-001, 3.538203e-001, 0.000000e+000
1247, -1.832745e-001, 3.547044e-001, 0.000000e+000
1248, -1.837454e-001, 3.555886e-001, 0.000000e+000
1249, -1.842164e-001, 3.564727e-001, 0.000000e+000
1250, -1.846873e-001, 3.573569e-001, 0.000000e+000
1251, -1.851583e-001, 3.582410e-001, 0.000000e+000
1252, -1.856292e-001, 3.591251e-001, 0.000000e+000
1253, -1.861002e-001, 3.600093e-001, 0.000000e+000
1254, -1.865711e-001, 3.608934e-001, 0.000000e+000
1255, -1.870421e-001, 3.617776e-001, 0.000000e+000
1256, -1.875130e-001, 3.626617e-001, 0.000000e+000
1257, -1.879840e-001, 3.635458e-001, 0.000000e+000
1258, -1.884549e-001, 3.644300e-001, 0.000000e+000
1259, -1.889259e-001, 3.653141e-001, 0.000000e+000
1260, -1.893968e-001, 3.661983e-001, 0.000000e+000
1261, -1.898678e-001, 3.670824e-001, 0.000000e+000
1262, -1.903387e-001, 3.679666e-001, 0.000000e+000
1263, -1.908097e-001, 3.688507e-001, 0.000000e+000
1264, -1.912806e-001, 3.697348e-001, 0.000000e+000
1265, -1.917516e-001, 3.706190e-001, 0.000000e+000
1266, -1.922226e-001, 3.715031e-001, 0.000000e+000
1267, -1.926935e-001, 3.723873e-001, 0.000000e+000
1268, -1.931645e-001, 3.732714e-001, 0.000000e+000
1269, -1.936354e-001, 3.741555e-001, 0.000000e+000
1270, -1.941064e-001, 3.750397e-001, 0.000000e+000
1271, -1.945773e-001, 3.759238e-001, 0.000000e+000
1272, -1.950483e-001, 3.768080e-001, 0.000000e+000
1273, -1.955192e-001, 3.776921e-001, 0.000000e+000
1274, -1.959902e-001, 3.785763e-001, 0.000000e+000
1275, -1.964611e-001, 3.794604e-001, 0.000000e+000
1276, -1.969321e-001, 3.803445e-001, 0.000000e+000
1277, -1.974030e-001, 3.812287e-001, 0.000000e+000
1278, -1.978740e-001, 3.821128e-001, 0.000000e+000
1279, -1.983449e-001, 3.829970e-001, 0.000000e+000
1280, -1.988159e-001, 3.838811e-001, 0.000000e+000
1281, -1.992868e-001, 3.847652e-001, 0.000000e+000
1282, -1.997578e-001, 3.856494e-001, 0.000000e+000
1283, -2.002287e-001, 3.865335e-001, 0.000000e+000
1284, -2.006997e-001, 3.874177e-001, 0.000000e+000
1285, -2.011706e-001, 3.883018e-001, 0.000000e+000
1286, -2.016416e-001, 3.891859e-001, 0.000000e+000
1287, -2.021125e-001, 3.900701e-001, 0.000000e+000
1288, -2.025835e-001, 3.909542e-001, 0.000000e+000
1289, -2.030544e-001, 3.918384e-001, 0.000000e+000
1290, -2.035254e-001, 3.927225e-001, 0.000000e+000
1291, -2.039963e-001, 3.936067e-001, 0.000000e+000
1292, -2.044673e-001, 3.944908e-001, 0.000000e+000
1293, -2.049382e-001, 3.953749e-001, 0.000000e+000
1294, -2.054092e-001, 3.962591e-001, 0.000000e+000
1295, -2.058801e-001, 3.971432e-001, 0.000000e+000
1296, -2.063511e-001, 3.980274e-001, 0.000000e+000
1297, -2.068220e-001, 3.989115e-001, 0.000000e+000
1298, -2.072930e-001, 3.997956e-001, 0.000000e+000
1299, -2.077639e-001, 4.006798e-001, 0.000000e+000
1300, -2.082349e-001, 4.015639e-001, 0.000000e+000
1301, -2.087058e-001, 4.024481e-001, 0.000000e+000
1302, -2.091768e-001, 4.033322e-001, 0.000000e+000
1303, -2.096477e-001, 4.042164e-001, 0.000000e+000
1304, -2.101187e-001, 4.051005e-001, 0.000000e+000
1305, -2.105897e-001, 4.059846e-001, 0.000000e+000
1306, -2.110606e-001, 4.068688e-001, 0.000000e+000
1307, -2.115316e-001, 4.077529e-001, 0.000000e+000
1308, -2.120025e-001, 4.086371e-001, 0.000000e+000
1309, -2.124735e-001, 4.095212e-001, 0.000000e+000
1310, -2.129444e-001, 4.104053e-001, 0.000000e+000
1311, -2.134154e-001, 4.112895e-001, 0.000000e+000
1312, -2.138863e-001, 4.121736e-001, 0.000000e+000
1313, -2.144205e-001, 4.130241e-001, 9.961416e-004
1314, -2.146078e-001, 4.129243e-001, 1.972064e-003
1315, -2.149156e-001, 4.127604e-001, 2.907879e-003
1316, -2.153383e-001, 4.125352e-001, 3.784253e-003
1317, -2.158664e-001, 4.122539e-001, 4.583935e-003
1318, -2.164897e-001, 4.119219e-001, 5.290124e-003
1319, -2.171955e-001, 4.115460e-001, 5.888419e-003
1320, -2.179690e-001, 4.111339e-001, 6.367385e-003
1321, -2.187949e-001, 4.106940e-001, 6.716187e-003
1322, -2.196563e-001, 4.102352e-001, 6.928385e-003
1323, -2.205354e-001, 4.097669e-001, 7.000000e-003
1324, -2.214146e-001, 4.092986e-001, 6.928385e-003
1325, -2.222760e-001, 4.088397e-001, 6.716187e-003
1326, -2.231019e-001, 4.083998e-001, 6.367385e-003
1327, -2.238754e-001, 4.079878e-001, 5.888419e-003
1328, -2.245812e-001, 4.076118e-001, 5.290124e-003
1329, -2.252045e-001, 4.072798e-001, 4.583935e-003
1330, -2.257326e-001, 4.069986e-001, 3.784253e-003
1331, -2.261553e-001, 4.067734e-001, 2.907879e-003
1332, -2.264631e-001, 4.066094e-001, 1.972064e-003
1333, -2.266504e-001, 4.065096e-001, 9.961416e-004
1334, -2.262441e-001, 4.055946e-001, 0.000000e+000
1335, -2.257747e-001, 4.047132e-001, 0.000000e+000
1336, -2.253052e-001, 4.038318e-001, 0.000000e+000
1337, -2.248357e-001, 4.029504e-001, 0.000000e+000
1338, -2.243662e-001, 4.020690e-001, 0.000000e+000
1339, -2.238967e-001, 4.011877e-001, 0.000000e+000
1340, -2.234273e-001, 4.003063e-001, 0.000000e+000
1341, -2.229578e-001, 3.994249e-001, 0.000000e+000
1342, -2.224883e-001, 3.985435e-001, 0.000000e+000
1343, -2.220188e-001, 3.976621e-001, 0.000000e+000
1344, -2.215493e-001, 3.967807e-001, 0.000000e+000
1345, -2.210798e-001, 3.958994e-001, 0.000000e+000
1346, -2.206104e-001, 3.950180e-001, 0.000000e+000
1347, -2.201409e-001, 3.941366e-001, 0.000000e+000
1348, -2.196714e-001, 3.932552e-001, 0.000000e+000
1349, -2.192019e-001, 3.923738e-001, 0.000000e+000
1350, -2.187324e-001, 3.914924e-001, 0.000000e+000
1351, -2.182629e-001, 3.906111e-001, 0.000000e+000
1352, -2.177935e-001, 3.897297e-001, 0.000000e+000
1353, -2.173240e-001, 3.888483e-001, 0.000000e+000
1354, -2.168545e-001, 3.879669e-001, 0.000000e+000
1355, -2.163850e-001, 3.870855e-001, 0.000000e+000
1356, -2.159155e-001, 3.862041e-001, 0.000000e+000
1357, -2.154461e-001, 3.853228e-001, 0.000000e+000
1358, -2.149766e-001, 3.844414e-001, 0.000000e+000
1359, -2.145071e-001, 3.835600e-001, 0.000000e+000
1360, -2.140376e-001, 3.826786e-001, 0.000000e+000
1361, -2.135681e-001, 3.817972e-001, 0.000000e+000
1362, -2.130986e-001, 3.809158e-001, 0.000000e+000
1363, -2.126292e-001, 3.800344e-001, 0.000000e+000
1364, -2.121597e-001, 3.791531e-001, 0.000000e+000
1365, -2.116902e-001, 3.782717e-001, 0.000000e+000
1366, -2.112207e-001, 3.773903e-001, 0.000000e+000
1367, -2.107512e-001, 3.765089e-001, 0.000000e+000
1368, -2.102817e-001, 3.756275e-001, 0.000000e+000
1369, -2.098123e-001, 3.747461e-001, 0.000000e+000
1370, -2.093428e-001, 3.738648e-001, 0.000000e+000
1371, -2.088733e-001, 3.729834e-001, 0.000000e+000
1372, -2.084038e-001, 3.721020e-001, 0.000000e+000
1373, -2.079343e-001, 3.712206e-001, 0.000000e+000
1374, -2.074649e-001, 3.703392e-001, 0.000000e+000
1375, -2.069954e-001, 3.694578e-001, 0.000000e+000
1376, -2.065259e-001, 3.685765e-001, 0.000000e+000
1377, -2.060564e-001, 3.676951e-001, 0.000000e+000
1378, -2.055869e-001, 3.668137e-001, 0.000000e+000
1379, -2.051174e-001, 3.659323e-001, 0.000000e+000
1380, -2.046480e-001, 3.650509e-001, 0.000000e+000
1381, -2.041785e-001, 3.641695e-001, 0.000000e+000
1382, -2.037090e-001, 3.632882e-001, 0.000000e+000
1383, -2.032395e-001, 3.624068e-001, 0.000000e+000
1384, -2.027700e-001, 3.615254e-001, 0.000000e+000
1385, -2.023005e-001, 3.606440e-001, 0.000000e+000
1386, -2.018311e-001, 3.597626e-001, 0.000000e+000
1387, -2.013616e-001, 3.588812e-001, 0.000000e+000
1388, -2.008921e-001, 3.579999e-001, 0.000000e+000
1389, -2.004226e-001, 3.571185e-001, 0.000000e+000
1390, -1.999531e-001, 3.562371e-001, 0.000000e+000
1391, -1.994837e-001, 3.553557e-001, 0.000000e+000
1392, -1.990142e-001, 3.544743e-001, 0.000000e+000
1393, -1.985447e-001, 3.535929e-001, 0.000000e+000
1394, -1.980752e-001, 3.527115e-001, 0.000000e+000
1395, -1.976057e-001, 3.518302e-001, 0.000000e+000
1396, -1.971362e-001, 3.509488e-001, 0.000000e+000
1397, -1.966668e-001, 3.500674e-001, 0.000000e+000
1398, -1.961973e-001, 3.491860e-001, 0.000000e+000
1399, -1.957278e-001, 3.483046e-001, 0.000000e+000
1400, -1.952583e-001, 3.474232e-001, 0.000000e+000
1401, -1.947888e-001, 3.465419e-001, 0.000000e+000
1402, -1.943193e-001, 3.456605e-001, 0.000000e+000
1403, -1.938499e-001, 3.447791e-001, 0.000000e+000
1404, -1.933804e-001, 3.438977e-001, 0.000000e+000
1405, -1.929109e-001, 3.430163e-001, 0.000000e+000
1406, -1.924414e-001, 3.421349e-001, 0.000000e+000
1407, -1.919719e-001, 3.412536e-001, 0.000000e+000
1408, -1.915024e-001, 3.403722e-001, 0.000000e+000
1409, -1.910330e-001, 3.394908e-001, 0.000000e+000
1410, -1.905635e-001, 3.386094e-001, 0.000000e+000
1411, -1.900940e-001, 3.377280e-001, 0.000000e+000
1412, -1.896245e-001, 3.368466e-001, 0.000000e+000
1413, -1.891550e-001, 3.359653e-001, 0.000000e+000
1414, -1.886856e-001, 3.350839e-001, 0.000000e+000
1415, -1.882161e-001, 3.342025e-001, 0.000000e+000
1416, -1.877466e-001, 3.333211e-001, 0.000000e+000
1417, -1.872771e-001, 3.324397e-001, 0.000000e+000
1418, -1.868076e-001, 3.315583e-001, 0.000000e+000
1419, -1.863381e-001, 3.306770e-001, 0.000000e+000
1420, -1.858687e-001, 3.297956e-001, 0.000000e+000
1421, -1.853992e-001, 3.289142e-001, 0.000000e+000
1422, -1.849297e-001, 3.280328e-001, 0.000000e+000
1423, -1.844602e-001, 3.271514e-001, 0.000000e+000
1424, -1.839907e-001, 3.262700e-001, 0.000000e+000
1425, -1.835212e-001, 3.253886e-001, 0.000000e+000
1426, -1.830518e-001, 3.245073e-001, 0.000000e+000
1427, -1.825823e-001, 3.236259e-001, 0.000000e+000
1428, -1.821128e-001, 3.227445e-001, 0.000000e+000
1429, -1.816433e-001, 3.218631e-001, 0.000000e+000
1430, -1.811738e-001, 3.209817e-001, 0.000000e+000
1431, -1.807044e-001, 3.201003e-001, 0.000000e+000
1432, -1.802349e-001, 3.192190e-001, 0.000000e+000
1433, -1.797654e-001, 3.183376e-001, 0.000000e+000
1434, -1.792959e-001, 3.174562e-001, 0.000000e+000
1435, -1.788264e-001, 3.165748e-001, 0.000000e+000
1436, -1.783569e-001, 3.156934e-001, 0.000000e+000
1437, -1.778875e-001, 3.148120e-001, 0.000000e+000
1438, -1.774180e-001, 3.139307e-001, 0.000000e+000
1439, -1.769485e-001, 3.130493e-001, 0.000000e+000
1440, -1.764790e-001, 3.121679e-001, 0.000000e+000
1441, -1.760095e-001, 3.112865e-001, 0.000000e+000
1442, -1.755400e-001, 3.104051e-001, 0.000000e+000
1443, -1.750706e-001, 3.095237e-001, 0.000000e+000
1444, -1.746011e-001, 3.086424e-001, 0.000000e+000
1445, -1.741316e-001, 3.077610e-001, 0.000000e+000
1446, -1.736621e-001, 3.068796e-001, 0.000000e+000
1447, -1.731926e-001, 3.059982e-001, 0.000000e+000
1448, -1.727232e-001, 3.051168e-001, 0.000000e+000
1449, -1.722537e-001, 3.042354e-001, 0.000000e+000
1450, -1.717842e-001, 3.033541e-001, 0.000000e+000
1451, -1.713147e-001, 3.024727e-001, 0.000000e+000
1452, -1.708452e-001, 3.015913e-001, 0.000000e+000
1453, -1.703757e-001, 3.007099e-001, 0.000000e+000
1454, -1.699063e-001, 2.998285e-001, 0.000000e+000
1455, -1.694368e-001, 2.989471e-001, 0.000000e+000
1456, -1.689673e-001, 2.980657e-001, 0.000000e+000
1457, -1.684978e-001, 2.971844e-001, 0.000000e+000
1458, -1.680283e-001, 2.963030e-001, 0.000000e+000
1459, -1.675588e-001, 2.954216e-001, 0.000000e+000
1460, -1.670894e-001, 2.945402e-001, 0.000000e+000
1461, -1.666199e-001, 2.936588e-001, 0.000000e+000
1462, -1.661504e-001, 2.927774e-001, 0.000000e+000
1463, -1.656809e-001, 2.918961e-001, 0.000000e+000
1464, -1.652114e-001, 2.910147e-001, 0.000000e+000
1465, -1.647420e-001, 2.901333e-001, 0.000000e+000
1466, -1.642725e-001, 2.892519e-001, 0.000000e+000
1467, -1.638030e-001, 2.883705e-001, 0.000000e+000
1468, -1.633335e-001, 2.874891e-001, 0.000000e+000
1469, -1.628640e-001, 2.866078e-001, 0.000000e+000
1470, -1.623945e-001, 2.857264e-001, 0.000000e+000
1471, -1.619251e-001, 2.848450e-001, 0.000000e+000
1472, -1.614556e-001, 2.839636e-001, 0.000000e+000
1473, -1.609861e-001, 2.830822e-001, 0.000000e+000
1474, -1.605166e-001, 2.822008e-001, 0.000000e+000
1475, -1.600471e-001, 2.813195e-001, 0.000000e+000
1476, -1.595776e-001, 2.804381e-001, 0.000000e+000
1477, -1.591082e-001, 2.795567e-001, 0.000000e+000
1478, -1.586387e-001, 2.786753e-001, 0.000000e+000
1479, -1.581692e-001, 2.777939e-001, 0.000000e+000
1480, -1.576997e-001, 2.769125e-001, 0.000000e+000
1481, -1.572302e-001, 2.760312e-001, 0.000000e+000
1482, -1.567608e-001, 2.751498e-001, 0.000000e+000
1483, -1.562913e-001, 2.742684e-001, 0.000000e+000
1484, -1.558218e-001, 2.733870e-001, 0.000000e+000
1485, -1.553523e-001, 2.725056e-001, 0.000000e+000
1486, -1.548828e-001, 2.716242e-001, 0.000000e+000
1487, -1.544133e-001, 2.707428e-001, 0.000000e+000
1488, -1.539439e-001, 2.698615e-001, 0.000000e+000
1489, -1.534744e-001, 2.689801e-001, 0.000000e+000
1490, -1.530049e-001, 2.680987e-001, 0.000000e+000
1491, -1.525354e-001, 2.672173e-001, 0.000000e+000
1492, -1.520659e-001, 2.663359e-001, 0.000000e+000
1493, -1.515964e-001, 2.654545e-001, 0.000000e+000
1494, -1.511270e-001, 2.645732e-001, 0.000000e+000
1495, -1.506575e-001, 2.636918e-001, 0.000000e+000
1496, -1.501880e-001, 2.628104e-001, 0.000000e+000
1497, -1.497185e-001, 2.619290e-001, 0.000000e+000
1498, -1.492490e-001, 2.610476e-001, 0.000000e+000
1499, -1.487795e-001, 2.601662e-001, 0.000000e+000
1500, -1.483101e-001, 2.592849e-001, 0.000000e+000
1501, -1.478406e-001, 2.584035e-001, 0.000000e+000
1502, -1.473711e-001, 2.575221e-001, 0.000000e+000
1503, -1.469016e-001, 2.566407e-001, 0.000000e+000
1504, -1.464321e-001, 2.557593e-001, 0.000000e+000
1505, -1.327077e-001, 2.271409e-001, 0.000000e+000
1506, -1.325097e-001, 2.262321e-001, 0.000000e+000
1507, -1.186266e-001, 2.277951e-001, 9.962039e-004
1508, -1.188355e-001, 2.277573e-001, 1.972128e-003
1509, -1.191790e-001, 2.276953e-001, 2.907905e-003
1510, -1.196500e-001, 2.276102e-001, 3.784486e-003
1511, -1.202390e-001, 2.275038e-001, 4.584025e-003
1512, -1.209340e-001, 2.273782e-001, 5.290247e-003
1513, -1.217208e-001, 2.272361e-001, 5.888775e-003
1514, -1.225834e-001, 2.270803e-001, 6.367424e-003
1515, -1.235043e-001, 2.269139e-001, 6.716451e-003
1516, -1.244647e-001, 2.267404e-001, 6.928750e-003
1517, -1.254450e-001, 2.265633e-001, 7.000000e-003
1518, -1.264253e-001, 2.263862e-001, 6.928750e-003
1519, -1.273857e-001, 2.262127e-001, 6.716451e-003
1520, -1.283066e-001, 2.260464e-001, 6.367424e-003
1521, -1.291692e-001, 2.258905e-001, 5.888775e-003
1522, -1.299560e-001, 2.257484e-001, 5.290247e-003
1523, -1.306510e-001, 2.256229e-001, 4.584025e-003
1524, -1.312400e-001, 2.255165e-001, 3.784486e-003
1525, -1.317110e-001, 2.254314e-001, 2.907905e-003
1526, -1.320545e-001, 2.253693e-001, 1.972128e-003
1527, -1.322634e-001, 2.253316e-001, 9.962039e-004
1528, -1.187493e-001, 2.288187e-001, 0.000000e+000
1529, -1.189617e-001, 2.298258e-001, 0.000000e+000
1530, -1.191936e-001, 2.308286e-001, 0.000000e+000
1531, -1.194449e-001, 2.318266e-001, 0.000000e+000
1532, -1.197156e-001, 2.328196e-001, 0.000000e+000
1533, -1.200055e-001, 2.338072e-001, 0.000000e+000
1534, -1.203145e-001, 2.347889e-001, 0.000000e+000
1535, -1.206425e-001, 2.357645e-001, 0.000000e+000
1536, -1.209894e-001, 2.367335e-001, 0.000000e+000
1537, -1.213551e-001, 2.376955e-001, 0.000000e+000
1538, -1.217394e-001, 2.386503e-001, 0.000000e+000
1539, -1.221421e-001, 2.395975e-001, 0.000000e+000
1540, -1.225632e-001, 2.405367e-001, 0.000000e+000
1541, -1.230024e-001, 2.414675e-001, 0.000000e+000
1542, -1.234596e-001, 2.423896e-001, 0.000000e+000
1543, -1.284573e-001, 2.038618e-001, 0.000000e+000
1544, -1.286335e-001, 2.048371e-001, 0.000000e+000
1545, -1.288097e-001, 2.058125e-001, 0.000000e+000
1546, -1.289858e-001, 2.067878e-001, 0.000000e+000
1547, -1.291620e-001, 2.077631e-001, 0.000000e+000
1548, -1.293382e-001, 2.087384e-001, 0.000000e+000
1549, -1.295144e-001, 2.097137e-001, 0.000000e+000
1550, -1.296906e-001, 2.106891e-001, 0.000000e+000
1551, -1.298668e-001, 2.116644e-001, 0.000000e+000
1552, -1.300430e-001, 2.126397e-001, 0.000000e+000
1553, -1.302192e-001, 2.136150e-001, 0.000000e+000
1554, -1.303954e-001, 2.145904e-001, 0.000000e+000
1555, -1.305716e-001, 2.155657e-001, 0.000000e+000
1556, -1.307478e-001, 2.165410e-001, 0.000000e+000
1557, -1.309240e-001, 2.175163e-001, 0.000000e+000
1558, -1.311002e-001, 2.184916e-001, 0.000000e+000
1559, -1.312763e-001, 2.194670e-001, 0.000000e+000
1560, -1.314525e-001, 2.204423e-001, 0.000000e+000
1561, -1.316287e-001, 2.214176e-001, 0.000000e+000
1562, -1.318049e-001, 2.223929e-001, 0.000000e+000
1563, -1.319811e-001, 2.233683e-001, 0.000000e+000
1564, -1.321573e-001, 2.243436e-001, 0.000000e+000
1565, -1.183803e-001, 2.268324e-001, 0.000000e+000
1566, -1.182041e-001, 2.258571e-001, 0.000000e+000
1567, -1.180279e-001, 2.248818e-001, 0.000000e+000
1568, -1.178517e-001, 2.239064e-001, 0.000000e+000
1569, -1.176755e-001, 2.229311e-001, 0.000000e+000
1570, -1.174993e-001, 2.219558e-001, 0.000000e+000
1571, -1.173232e-001, 2.209805e-001, 0.000000e+000
1572, -1.171470e-001, 2.200051e-001, 0.000000e+000
1573, -1.169708e-001, 2.190298e-001, 0.000000e+000
1574, -1.167946e-001, 2.180545e-001, 0.000000e+000
1575, -1.166184e-001, 2.170792e-001, 0.000000e+000
1576, -1.164422e-001, 2.161039e-001, 0.000000e+000
1577, -1.162660e-001, 2.151285e-001, 0.000000e+000
1578, -1.160898e-001, 2.141532e-001, 0.000000e+000
1579, -1.159136e-001, 2.131779e-001, 0.000000e+000
1580, -1.157374e-001, 2.122026e-001, 0.000000e+000
1581, -1.155612e-001, 2.112272e-001, 0.000000e+000
1582, -1.153850e-001, 2.102519e-001, 0.000000e+000
1583, -1.152088e-001, 2.092766e-001, 0.000000e+000
1584, -1.150327e-001, 2.083013e-001, 0.000000e+000
1585, -1.148565e-001, 2.073260e-001, 0.000000e+000
1586, -1.146803e-001, 2.063506e-001, 0.000000e+000
1587, -8.300324e-002, -1.393170e-002, 1.620449e-002
1588, -8.392699e-002, -1.422220e-002, 1.641521e-002
1589, -8.478457e-002, -1.457938e-002, 1.675995e-002
1590, -8.555268e-002, -1.499351e-002, 1.722931e-002
1591, -8.621044e-002, -1.545333e-002, 1.781052e-002
1592, -8.673987e-002, -1.594629e-002, 1.848774e-002
1593, -8.712653e-002, -1.645895e-002, 1.924249e-002
1594, -8.735985e-002, -1.697731e-002, 2.005417e-002
1595, -8.743348e-002, -1.748724e-002, 2.090066e-002
1596, -8.734539e-002, -1.797482e-002, 2.175884e-002
1597, -8.709801e-002, -1.842676e-002, 2.260533e-002
1598, -8.669806e-002, -1.883072e-002, 2.341702e-002
1599, -8.615646e-002, -1.917570e-002, 2.417177e-002
1600, -8.548800e-002, -1.945227e-002, 2.484900e-002
1601, -8.471088e-002, -1.965289e-002, 2.543024e-002
1602, -8.384633e-002, -1.977209e-002, 2.589963e-002
1603, -8.291792e-002, -1.980663e-002, 2.624436e-002
1604, -8.195096e-002, -1.975555e-002, 2.645503e-002
1605, -8.097185e-002, -1.962025e-002, 2.652590e-002
1606, -8.284718e-002, -1.479663e-002, 1.569710e-002
1607, -8.269112e-002, -1.566156e-002, 1.518970e-002
1608, -8.253515e-002, -1.652651e-002, 1.468232e-002
1609, -8.237938e-002, -1.739152e-002, 1.417497e-002
1610, -8.222398e-002, -1.825663e-002, 1.366767e-002
1611, -8.206878e-002, -1.912179e-002, 1.316041e-002
1612, -8.191339e-002, -1.998689e-002, 1.265311e-002
1613, -8.175763e-002, -2.085191e-002, 1.214576e-002
1614, -8.160162e-002, -2.171685e-002, 1.163837e-002
1615, -8.144547e-002, -2.258176e-002, 1.113097e-002
1616, -8.128927e-002, -2.344665e-002, 1.062355e-002
1617, -8.113268e-002, -2.431172e-002, 1.011593e-002
1618, -8.097466e-002, -2.517766e-002, 9.607417e-003
1619, -8.081393e-002, -2.604731e-002, 9.096133e-003
1620, -8.064826e-002, -2.692117e-002, 8.581168e-003
1621, -8.046114e-002, -2.777551e-002, 8.070508e-003
1622, -8.018928e-002, -2.848884e-002, 7.613319e-003
1623, -7.999595e-002, -2.900410e-002, 7.286239e-003
1624, -7.757527e-002, -2.845347e-002, 7.611347e-003
1625, -7.675371e-002, -2.899386e-002, 7.532825e-003
1626, -7.602279e-002, -2.998553e-002, 7.219149e-003
1627, -7.538309e-002, -3.083774e-002, 7.028142e-003
1628, -7.480519e-002, -3.170197e-002, 6.855985e-003
1629, -7.428520e-002, -3.258714e-002, 6.682858e-003
1630, -7.381498e-002, -3.348717e-002, 6.505814e-003
1631, -7.338570e-002, -3.439770e-002, 6.325899e-003
1632, -7.299054e-002, -3.531628e-002, 6.144600e-003
1633, -7.262465e-002, -3.624144e-002, 5.963266e-003
1634, -7.228453e-002, -3.717213e-002, 5.783351e-003
1635, -7.196770e-002, -3.810756e-002, 5.606472e-003
1636, -7.167247e-002, -3.904706e-002, 5.434417e-003
1637, -7.139781e-002, -3.999006e-002, 5.269450e-003
1638, -7.114337e-002, -4.093593e-002, 5.114389e-003
1639, -7.090958e-002, -4.188373e-002, 4.972805e-003
1640, -7.069778e-002, -4.283203e-002, 4.849728e-003
1641, -7.051069e-002, -4.377840e-002, 4.752114e-003
1642, -7.035311e-002, -4.471854e-002, 4.689530e-003
1643, -7.023260e-002, -4.564513e-002, 4.672944e-003
1644, -7.015940e-002, -4.654952e-002, 4.712476e-003
1645, -7.014758e-002, -4.742274e-002, 4.820902e-003
1646, -7.021886e-002, -4.825124e-002, 5.017441e-003
1647, -7.040136e-002, -4.900898e-002, 5.316392e-003
1648, -7.070895e-002, -4.968568e-002, 5.688435e-003
1649, -7.114933e-002, -5.028018e-002, 6.100029e-003
1650, -7.172770e-002, -5.079476e-002, 6.518193e-003
1651, -7.244117e-002, -5.123223e-002, 6.904310e-003
1652, -7.326323e-002, -5.159821e-002, 7.209358e-003
1653, -7.416519e-002, -5.189126e-002, 7.402871e-003
1654, -7.511634e-002, -5.210586e-002, 7.468058e-003
1655, -7.608516e-002, -5.223570e-002, 7.398924e-003
1656, -7.704061e-002, -5.227342e-002, 7.199718e-003
1657, -7.795297e-002, -5.221097e-002, 6.884775e-003
1658, -7.879455e-002, -5.203771e-002, 6.481001e-003
1659, -7.953997e-002, -5.174116e-002, 6.031583e-003
1660, -8.017086e-002, -5.131203e-002, 5.595281e-003
1661, -8.069244e-002, -5.075907e-002, 5.209108e-003
1662, -8.111508e-002, -5.009549e-002, 4.905892e-003
1663, -8.145532e-002, -4.934536e-002, 4.698429e-003
1664, -8.173236e-002, -4.853147e-002, 4.582002e-003
1665, -8.196287e-002, -4.767085e-002, 4.542171e-003
1666, -8.215873e-002, -4.677531e-002, 4.562390e-003
1667, -8.232725e-002, -4.585362e-002, 4.627824e-003
1668, -8.247257e-002, -4.491292e-002, 4.726997e-003
1669, -8.259693e-002, -4.395879e-002, 4.851113e-003
1670, -8.270147e-002, -4.299525e-002, 4.993691e-003
1671, -8.278660e-002, -4.202500e-002, 5.149879e-003
1672, -8.285217e-002, -4.104976e-002, 5.316166e-003
1673, -8.289751e-002, -4.007054e-002, 5.489743e-003
1674, -8.292137e-002, -3.908792e-002, 5.668327e-003
1675, -8.292195e-002, -3.810229e-002, 5.850131e-003
1676, -8.289667e-002, -3.711390e-002, 6.033530e-003
1677, -8.284201e-002, -3.612294e-002, 6.217064e-003
1678, -8.275307e-002, -3.512963e-002, 6.399335e-003
1679, -8.262266e-002, -3.413436e-002, 6.578509e-003
1680, -8.243978e-002, -3.313907e-002, 6.751667e-003
1681, -8.218733e-002, -3.215720e-002, 6.910893e-003
1682, -8.186034e-002, -3.125659e-002, 7.040109e-003
1683, -8.151220e-002, -3.057206e-002, 7.121461e-003
1684, -8.107321e-002, -2.977296e-002, 7.269922e-003
1685, -8.105938e-002, -1.358052e-002, 1.620446e-002
1686, -8.090314e-002, -1.444540e-002, 1.569704e-002
1687, -8.074690e-002, -1.531028e-002, 1.518962e-002
1688, -8.059066e-002, -1.617517e-002, 1.468220e-002
1689, -8.043442e-002, -1.704005e-002, 1.417478e-002
1690, -8.027817e-002, -1.790493e-002, 1.366735e-002
1691, -8.012193e-002, -1.876981e-002, 1.315993e-002
1692, -7.996569e-002, -1.963469e-002, 1.265251e-002
1693, -7.980945e-002, -2.049957e-002, 1.214509e-002
1694, -7.965321e-002, -2.136445e-002, 1.163767e-002
1695, -7.949698e-002, -2.222933e-002, 1.113025e-002
1696, -7.934012e-002, -2.309458e-002, 1.062266e-002
1697, -7.918229e-002, -2.395976e-002, 1.011519e-002
1698, -7.901836e-002, -2.482518e-002, 9.608121e-003
1699, -7.887630e-002, -2.570567e-002, 9.090060e-003
1700, -7.879215e-002, -2.660084e-002, 8.558816e-003
1701, -7.873279e-002, -2.749266e-002, 8.029406e-003
1702, -7.848091e-002, -2.830240e-002, 7.560795e-003
1703, -8.000729e-002, -1.940442e-002, 2.645503e-002
1704, -7.908359e-002, -1.911395e-002, 2.624436e-002
1705, -7.822593e-002, -1.875677e-002, 2.589963e-002
1706, -7.745773e-002, -1.834260e-002, 2.543024e-002
1707, -7.679994e-002, -1.788276e-002, 2.484900e-002
1708, -7.627048e-002, -1.738979e-002, 2.417177e-002
1709, -7.588382e-002, -1.687713e-002, 2.341702e-002
1710, -7.565050e-002, -1.635876e-002, 2.260533e-002
1711, -7.557687e-002, -1.584883e-002, 2.175884e-002
1712, -7.566495e-002, -1.536125e-002, 2.090065e-002
1713, -7.591234e-002, -1.490931e-002, 2.005417e-002
1714, -7.631229e-002, -1.450535e-002, 1.924248e-002
1715, -7.685388e-002, -1.416037e-002, 1.848772e-002
1716, -7.752235e-002, -1.388380e-002, 1.781049e-002
1717, -7.829946e-002, -1.368318e-002, 1.722925e-002
1718, -7.916401e-002, -1.356398e-002, 1.675987e-002
1719, -8.009243e-002, -1.352944e-002, 1.641514e-002
1720, -8.377098e-002, -1.508717e-002, 1.590786e-002
1721, -8.462852e-002, -1.544435e-002, 1.625262e-002
1722, -8.539653e-002, -1.585845e-002, 1.672195e-002
1723, -8.605424e-002, -1.631824e-002, 1.730314e-002
1724, -8.658366e-002, -1.681120e-002, 1.798036e-002
1725, -8.697030e-002, -1.732386e-002, 1.873511e-002
1726, -8.720362e-002, -1.784222e-002, 1.954679e-002
1727, -8.727724e-002, -1.835213e-002, 2.039327e-002
1728, -8.718915e-002, -1.883971e-002, 2.125144e-002
1729, -8.694176e-002, -1.929164e-002, 2.209792e-002
1730, -8.654182e-002, -1.969560e-002, 2.290960e-002
1731, -8.600022e-002, -2.004058e-002, 2.366435e-002
1732, -8.533175e-002, -2.031715e-002, 2.434158e-002
1733, -8.455464e-002, -2.051777e-002, 2.492282e-002
1734, -8.369009e-002, -2.063697e-002, 2.539221e-002
1735, -8.276167e-002, -2.067151e-002, 2.573694e-002
1736, -8.179472e-002, -2.062042e-002, 2.594761e-002
1737, -8.081561e-002, -2.048512e-002, 2.601848e-002
1738, -8.345926e-002, -1.681720e-002, 1.489325e-002
1739, -8.361501e-002, -1.595214e-002, 1.540052e-002
1740, -8.330397e-002, -1.768243e-002, 1.438613e-002
1741, -8.314949e-002, -1.854796e-002, 1.387926e-002
1742, -8.299547e-002, -1.941364e-002, 1.337253e-002
1743, -8.284106e-002, -2.027919e-002, 1.286568e-002
1744, -8.268582e-002, -2.114444e-002, 1.235857e-002
1745, -8.253003e-002, -2.200948e-002, 1.185129e-002
1746, -8.237396e-002, -2.287443e-002, 1.134392e-002
1747, -8.221775e-002, -2.373935e-002, 1.083649e-002
1748, -8.206100e-002, -2.460454e-002, 1.032866e-002
1749, -8.190262e-002, -2.547161e-002, 9.819100e-003
1750, -8.174296e-002, -2.634655e-002, 9.304986e-003
1751, -8.159042e-002, -2.724341e-002, 8.783494e-003
1752, -8.147479e-002, -2.821542e-002, 8.243377e-003
1753, -8.161495e-002, -2.902973e-002, 7.921396e-003
1754, -7.678258e-002, -2.810738e-002, 8.109460e-003
1755, -7.624367e-002, -2.827741e-002, 8.271657e-003
1756, -7.539671e-002, -2.965047e-002, 7.875648e-003
1757, -7.480193e-002, -3.053364e-002, 7.739957e-003
1758, -7.424644e-002, -3.146618e-002, 7.610813e-003
1759, -7.375187e-002, -3.241838e-002, 7.474740e-003
1760, -7.331228e-002, -3.337700e-002, 7.331054e-003
1761, -7.291893e-002, -3.433723e-002, 7.180377e-003
1762, -7.256372e-002, -3.529791e-002, 7.024693e-003
1763, -7.224084e-002, -3.625873e-002, 6.865854e-003
1764, -7.194622e-002, -3.721947e-002, 6.705667e-003
1765, -7.167711e-002, -3.817978e-002, 6.546011e-003
1766, -7.143170e-002, -3.913921e-002, 6.388957e-003
1767, -7.120904e-002, -4.009710e-002, 6.236948e-003
1768, -7.100895e-002, -4.105234e-002, 6.092981e-003
1769, -7.083220e-002, -4.200306e-002, 5.960894e-003
1770, -7.068065e-002, -4.294614e-002, 5.845813e-003
1771, -7.055761e-002, -4.387630e-002, 5.754572e-003
1772, -7.046816e-002, -4.478448e-002, 5.695218e-003
1773, -7.041770e-002, -4.565853e-002, 5.671883e-003
1774, -7.040966e-002, -4.648779e-002, 5.682417e-003
1775, -7.044804e-002, -4.726423e-002, 5.729613e-003
1776, -7.054792e-002, -4.797734e-002, 5.839150e-003
1777, -7.075268e-002, -4.858717e-002, 6.078255e-003
1778, -7.105437e-002, -4.913090e-002, 6.378273e-003
1779, -7.146421e-002, -4.962521e-002, 6.715417e-003
1780, -7.200121e-002, -5.007027e-002, 7.073542e-003
1781, -7.267358e-002, -5.046242e-002, 7.419706e-003
1782, -7.346342e-002, -5.080724e-002, 7.700693e-003
1783, -7.434194e-002, -5.109153e-002, 7.881235e-003
1784, -7.527496e-002, -5.130217e-002, 7.940911e-003
1785, -7.622693e-002, -5.142937e-002, 7.872332e-003
1786, -7.716266e-002, -5.146572e-002, 7.680324e-003
1787, -7.804824e-002, -5.140537e-002, 7.382375e-003
1788, -7.885202e-002, -5.124405e-002, 7.010343e-003
1789, -7.954762e-002, -5.098095e-002, 6.611309e-003
1790, -8.012012e-002, -5.061994e-002, 6.243635e-003
1791, -8.059239e-002, -5.017285e-002, 5.926938e-003
1792, -8.098263e-002, -4.963110e-002, 5.694084e-003
1793, -8.131286e-002, -4.900926e-002, 5.539017e-003
1794, -8.159981e-002, -4.831471e-002, 5.454489e-003
1795, -8.185467e-002, -4.755612e-002, 5.430068e-003
1796, -8.208452e-002, -4.674221e-002, 5.454326e-003
1797, -8.229304e-002, -4.588258e-002, 5.517004e-003
1798, -8.248180e-002, -4.498732e-002, 5.609515e-003
1799, -8.265138e-002, -4.406544e-002, 5.724725e-003
1800, -8.280198e-002, -4.312396e-002, 5.856829e-003
1801, -8.293351e-002, -4.216782e-002, 6.001162e-003
1802, -8.304553e-002, -4.120022e-002, 6.154041e-003
1803, -8.313724e-002, -4.022310e-002, 6.312475e-003
1804, -8.320732e-002, -3.923752e-002, 6.473987e-003
1805, -8.325386e-002, -3.824394e-002, 6.636483e-003
1806, -8.327415e-002, -3.724240e-002, 6.798062e-003
1807, -8.326441e-002, -3.623249e-002, 6.956901e-003
1808, -8.321927e-002, -3.521333e-002, 7.111069e-003
1809, -8.313056e-002, -3.418351e-002, 7.257883e-003
1810, -8.298457e-002, -3.314213e-002, 7.392234e-003
1811, -8.275727e-002, -3.209576e-002, 7.503064e-003
1812, -8.241291e-002, -3.107559e-002, 7.572570e-003
1813, -8.185652e-002, -3.004539e-002, 7.592300e-003
1814, -7.993619e-002, -1.439432e-002, 1.590771e-002
1815, -7.977995e-002, -1.525921e-002, 1.540029e-002
1816, -7.962371e-002, -1.612409e-002, 1.489287e-002
1817, -7.946746e-002, -1.698897e-002, 1.438545e-002
1818, -7.931122e-002, -1.785385e-002, 1.387803e-002
1819, -7.915498e-002, -1.871873e-002, 1.337060e-002
1820, -7.899874e-002, -1.958361e-002, 1.286318e-002
1821, -7.884250e-002, -2.044849e-002, 1.235576e-002
1822, -7.868626e-002, -2.131337e-002, 1.184834e-002
1823, -7.852978e-002, -2.217842e-002, 1.134088e-002
1824, -7.837180e-002, -2.304417e-002, 1.083340e-002
1825, -7.820816e-002, -2.391109e-002, 1.032682e-002
1826, -7.803949e-002, -2.478402e-002, 9.817862e-003
1827, -7.789991e-002, -2.573895e-002, 9.248119e-003
1828, -7.795733e-002, -2.666727e-002, 8.644911e-003
1829, -7.803922e-002, -2.741185e-002, 8.161902e-003
1830, -7.985105e-002, -2.026930e-002, 2.594761e-002
1831, -7.892735e-002, -1.997883e-002, 2.573694e-002
1832, -7.806969e-002, -1.962165e-002, 2.539221e-002
1833, -7.730149e-002, -1.920749e-002, 2.492282e-002
1834, -7.664369e-002, -1.874765e-002, 2.434158e-002
1835, -7.611424e-002, -1.825467e-002, 2.366435e-002
1836, -7.572758e-002, -1.774201e-002, 2.290960e-002
1837, -7.549425e-002, -1.722364e-002, 2.209791e-002
1838, -7.542063e-002, -1.671371e-002, 2.125142e-002
1839, -7.550871e-002, -1.622612e-002, 2.039323e-002
1840, -7.575610e-002, -1.577419e-002, 1.954675e-002
1841, -7.615604e-002, -1.537022e-002, 1.873506e-002
1842, -7.669764e-002, -1.502525e-002, 1.798030e-002
1843, -7.736611e-002, -1.474868e-002, 1.730307e-002
1844, -7.814322e-002, -1.454806e-002, 1.672183e-002
1845, -7.900777e-002, -1.442886e-002, 1.625245e-002
1846, -7.594248e-002, -2.885141e-002, 8.056839e-003
1847, -8.087567e-002, -2.892795e-002, 7.609682e-003
1848, -8.447252e-002, -1.630935e-002, 1.574532e-002
1849, -8.524045e-002, -1.672343e-002, 1.621465e-002
1850, -8.589814e-002, -1.718324e-002, 1.679587e-002
1851, -8.642755e-002, -1.767623e-002, 1.747315e-002
1852, -8.681416e-002, -1.818888e-002, 1.822793e-002
1853, -8.704742e-002, -1.870720e-002, 1.903960e-002
1854, -8.712100e-002, -1.921707e-002, 1.988602e-002
1855, -8.703290e-002, -1.970459e-002, 2.074414e-002
1856, -8.678551e-002, -2.015650e-002, 2.159057e-002
1857, -8.638557e-002, -2.056046e-002, 2.240222e-002
1858, -8.584398e-002, -2.090544e-002, 2.315695e-002
1859, -8.517551e-002, -2.118201e-002, 2.383417e-002
1860, -8.439840e-002, -2.138264e-002, 2.441541e-002
1861, -8.353385e-002, -2.150183e-002, 2.488480e-002
1862, -8.260544e-002, -2.153635e-002, 2.522953e-002
1863, -8.163849e-002, -2.148526e-002, 2.544022e-002
1864, -8.065938e-002, -2.134996e-002, 2.551109e-002
1865, -8.431681e-002, -1.717448e-002, 1.523817e-002
1866, -8.416193e-002, -1.804001e-002, 1.473142e-002
1867, -8.370231e-002, -2.063896e-002, 1.321375e-002
1868, -8.385553e-002, -1.977264e-002, 1.371964e-002
1869, -8.354763e-002, -2.150459e-002, 1.270711e-002
1870, -8.339202e-002, -2.236978e-002, 1.220000e-002
1871, -8.323598e-002, -2.323478e-002, 1.169267e-002
1872, -8.307976e-002, -2.409973e-002, 1.118523e-002
1873, -8.292312e-002, -2.496484e-002, 1.067741e-002
1874, -8.276508e-002, -2.583099e-002, 1.016811e-002
1875, -8.260599e-002, -2.670061e-002, 9.656476e-003
1876, -8.245703e-002, -2.757325e-002, 9.150772e-003
1877, -8.235620e-002, -2.843179e-002, 8.686713e-003
1878, -8.230224e-002, -2.912442e-002, 8.333600e-003
1879, -7.656694e-002, -2.746026e-002, 8.652438e-003
1880, -7.596816e-002, -2.790106e-002, 8.712557e-003
1881, -7.376376e-002, -3.128244e-002, 8.437398e-003
1882, -7.330545e-002, -3.230198e-002, 8.336040e-003
1883, -7.290665e-002, -3.331884e-002, 8.222102e-003
1884, -7.255864e-002, -3.432712e-002, 8.094889e-003
1885, -7.225129e-002, -3.532781e-002, 7.958353e-003
1886, -7.197806e-002, -3.632188e-002, 7.815028e-003
1887, -7.173452e-002, -3.730989e-002, 7.667141e-003
1888, -7.151772e-002, -3.829193e-002, 7.516856e-003
1889, -7.132579e-002, -3.926780e-002, 7.366511e-003
1890, -7.115778e-002, -4.023676e-002, 7.218719e-003
1891, -7.101363e-002, -4.119731e-002, 7.076571e-003
1892, -7.089427e-002, -4.214667e-002, 6.943923e-003
1893, -7.080167e-002, -4.308010e-002, 6.825736e-003
1894, -7.073905e-002, -4.398952e-002, 6.728362e-003
1895, -7.070982e-002, -4.486280e-002, 6.656378e-003
1896, -7.071332e-002, -4.568730e-002, 6.604353e-003
1897, -7.074189e-002, -4.645482e-002, 6.556603e-003
1898, -7.078447e-002, -4.715852e-002, 6.500125e-003
1899, -7.083271e-002, -4.777428e-002, 6.438171e-003
1900, -7.105047e-002, -4.818464e-002, 6.678197e-003
1901, -7.135382e-002, -4.858233e-002, 6.968200e-003
1902, -7.175119e-002, -4.897170e-002, 7.283276e-003
1903, -7.225769e-002, -4.933877e-002, 7.610707e-003
1904, -7.289110e-002, -4.966792e-002, 7.934764e-003
1905, -7.365767e-002, -4.999691e-002, 8.198344e-003
1906, -7.451797e-002, -5.027718e-002, 8.367053e-003
1907, -7.543454e-002, -5.048624e-002, 8.420792e-003
1908, -7.636916e-002, -5.061252e-002, 8.352033e-003
1909, -7.728321e-002, -5.064937e-002, 8.166723e-003
1910, -7.813856e-002, -5.059437e-002, 7.885280e-003
1911, -7.890128e-002, -5.045266e-002, 7.541161e-003
1912, -7.954730e-002, -5.024034e-002, 7.175217e-003
1913, -8.006750e-002, -4.998117e-002, 6.828071e-003
1914, -8.048631e-002, -4.967289e-002, 6.528678e-003
1915, -8.082231e-002, -4.922964e-002, 6.378231e-003
1916, -8.112213e-002, -4.871130e-002, 6.289730e-003
1917, -8.139920e-002, -4.811400e-002, 6.258487e-003
1918, -8.166233e-002, -4.744195e-002, 6.271163e-003
1919, -8.191509e-002, -4.669984e-002, 6.318050e-003
1920, -8.215663e-002, -4.589702e-002, 6.393012e-003
1921, -8.238469e-002, -4.504550e-002, 6.491055e-003
1922, -8.259735e-002, -4.415666e-002, 6.607506e-003
1923, -8.279331e-002, -4.323952e-002, 6.737940e-003
1924, -8.297167e-002, -4.230057e-002, 6.878337e-003
1925, -8.313158e-002, -4.134409e-002, 7.025186e-003
1926, -8.327203e-002, -4.037268e-002, 7.175462e-003
1927, -8.339159e-002, -3.938773e-002, 7.326530e-003
1928, -8.348828e-002, -3.838971e-002, 7.476035e-003
1929, -8.355932e-002, -3.737829e-002, 7.621744e-003
1930, -8.360078e-002, -3.635235e-002, 7.761383e-003
1931, -8.360694e-002, -3.530973e-002, 7.892274e-003
1932, -8.356877e-002, -3.424723e-002, 8.010336e-003
1933, -8.347124e-002, -3.316265e-002, 8.108414e-003
1934, -8.329031e-002, -3.206071e-002, 8.175973e-003
1935, -8.299606e-002, -3.097014e-002, 8.202997e-003
1936, -8.260810e-002, -3.000183e-002, 8.203637e-003
1937, -8.400833e-002, -1.890613e-002, 1.422533e-002
1938, -7.885153e-002, -1.529374e-002, 1.574502e-002
1939, -7.869529e-002, -1.615862e-002, 1.523760e-002
1940, -7.853905e-002, -1.702350e-002, 1.473018e-002
1941, -7.838281e-002, -1.788838e-002, 1.422276e-002
1942, -7.822657e-002, -1.875326e-002, 1.371534e-002
1943, -7.807033e-002, -1.961814e-002, 1.320791e-002
1944, -7.791409e-002, -2.048303e-002, 1.270049e-002
1945, -7.775781e-002, -2.134793e-002, 1.219307e-002
1946, -7.760109e-002, -2.221316e-002, 1.168566e-002
1947, -7.744193e-002, -2.307967e-002, 1.117863e-002
1948, -7.727446e-002, -2.395062e-002, 1.067286e-002
1949, -7.709802e-002, -2.486455e-002, 1.014253e-002
1950, -7.692199e-002, -2.602826e-002, 9.442199e-003
1951, -7.720874e-002, -2.699429e-002, 8.668183e-003
1952, -7.969482e-002, -2.113414e-002, 2.544022e-002
1953, -7.877111e-002, -2.084368e-002, 2.522953e-002
1954, -7.791346e-002, -2.048651e-002, 2.488479e-002
1955, -7.714525e-002, -2.007236e-002, 2.441540e-002
1956, -7.648745e-002, -1.961252e-002, 2.383417e-002
1957, -7.595800e-002, -1.911954e-002, 2.315694e-002
1958, -7.557134e-002, -1.860687e-002, 2.240219e-002
1959, -7.533802e-002, -1.808849e-002, 2.159051e-002
1960, -7.526440e-002, -1.757854e-002, 2.074403e-002
1961, -7.535248e-002, -1.709096e-002, 1.988584e-002
1962, -7.559986e-002, -1.663903e-002, 1.903935e-002
1963, -7.599981e-002, -1.623509e-002, 1.822764e-002
1964, -7.654140e-002, -1.589013e-002, 1.747288e-002
1965, -7.720987e-002, -1.561356e-002, 1.679565e-002
1966, -7.798698e-002, -1.541294e-002, 1.621441e-002
1967, -7.544319e-002, -2.852250e-002, 8.666349e-003
1968, -7.487080e-002, -2.933325e-002, 8.594235e-003
1969, -7.429196e-002, -3.027971e-002, 8.518235e-003
1970, -8.508472e-002, -1.758862e-002, 1.570760e-002
1971, -8.574246e-002, -1.804857e-002, 1.628905e-002
