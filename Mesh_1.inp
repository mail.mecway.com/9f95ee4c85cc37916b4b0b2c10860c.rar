9783, -9.942922e-002, 7.667070e-002, 2.209178e-002
9784, -9.925105e-002, 7.568442e-002, 2.209178e-002
9785, -9.907288e-002, 7.469813e-002, 2.209178e-002
9786, -9.889470e-002, 7.371185e-002, 2.209178e-002
9787, -9.871653e-002, 7.272557e-002, 2.209178e-002
9788, -9.853836e-002, 7.173928e-002, 2.209178e-002
9789, -9.836019e-002, 7.075300e-002, 2.209178e-002
9790, -9.818201e-002, 6.976671e-002, 2.209178e-002
9791, -9.800384e-002, 6.878043e-002, 2.209178e-002
9792, -9.782567e-002, 6.779415e-002, 2.209178e-002
9793, -9.764750e-002, 6.680786e-002, 2.209178e-002
9794, -9.746932e-002, 6.582158e-002, 2.209178e-002
9795, -9.729115e-002, 6.483529e-002, 2.209178e-002
9796, -9.711298e-002, 6.384901e-002, 2.209178e-002
9797, -9.693481e-002, 6.286272e-002, 2.209178e-002
9798, -9.675663e-002, 6.187644e-002, 2.209178e-002
9799, -9.657846e-002, 6.089016e-002, 2.209178e-002
9800, -9.640029e-002, 5.990387e-002, 2.209178e-002
9801, -9.622212e-002, 5.891759e-002, 2.209178e-002
9802, -9.604394e-002, 5.793130e-002, 2.209178e-002
9803, -9.586577e-002, 5.694502e-002, 2.209178e-002
9804, -9.568760e-002, 5.595874e-002, 2.209178e-002
9805, -9.550943e-002, 5.497245e-002, 2.209178e-002
9806, -9.533125e-002, 5.398617e-002, 2.209178e-002
9807, -9.515308e-002, 5.299988e-002, 2.209178e-002
9808, -9.497491e-002, 5.201360e-002, 2.209178e-002
9809, -9.479674e-002, 5.102732e-002, 2.209178e-002
9810, -9.461856e-002, 5.004103e-002, 2.209178e-002
9811, -9.444039e-002, 4.905475e-002, 2.209178e-002
9812, -9.426222e-002, 4.806846e-002, 2.209178e-002
9813, -9.408404e-002, 4.708218e-002, 2.209178e-002
9814, -9.390587e-002, 4.609589e-002, 2.209178e-002
9815, -9.372770e-002, 4.510961e-002, 2.209178e-002
9816, -9.354953e-002, 4.412333e-002, 2.209178e-002
9817, -9.337135e-002, 4.313704e-002, 2.209178e-002
9818, -9.319318e-002, 4.215076e-002, 2.209178e-002
9819, -9.301501e-002, 4.116447e-002, 2.209178e-002
9820, -9.283684e-002, 4.017819e-002, 2.209178e-002
9821, -9.265866e-002, 3.919191e-002, 2.209178e-002
9822, -9.248049e-002, 3.820562e-002, 2.209178e-002
9823, -9.230232e-002, 3.721934e-002, 2.209178e-002
9824, -9.212415e-002, 3.623305e-002, 2.209178e-002
9825, -9.194597e-002, 3.524677e-002, 2.209178e-002
9826, -9.176780e-002, 3.426048e-002, 2.209178e-002
9827, -9.158963e-002, 3.327420e-002, 2.209178e-002
9828, -9.141146e-002, 3.228792e-002, 2.209178e-002
9829, -9.123328e-002, 3.130163e-002, 2.209178e-002
9830, -9.105502e-002, 3.031535e-002, 2.209177e-002
9831, -9.087611e-002, 2.932909e-002, 2.209164e-002
9832, -9.069556e-002, 2.834276e-002, 2.209123e-002
9833, -9.051272e-002, 2.735611e-002, 2.209043e-002
9834, -9.032786e-002, 2.636883e-002, 2.208931e-002
9835, -9.014213e-002, 2.538082e-002, 2.208807e-002
9836, -1.073222e-001, 1.312608e-001, 2.206666e-002
9837, -1.058970e-001, 1.233705e-001, 2.206664e-002
9838, -1.126928e-001, 1.557676e-001, 2.200011e-002
9839, -1.114862e-001, 1.488411e-001, 2.200054e-002
9840, -1.116622e-001, 1.498278e-001, 2.200051e-002
9841, -1.118375e-001, 1.508149e-001, 2.200047e-002
9842, -1.125229e-001, 1.547738e-001, 2.200018e-002
9843, -1.088144e-001, 1.340467e-001, 2.200055e-002
9844, -1.089918e-001, 1.350331e-001, 2.200054e-002
9845, -1.084569e-001, 1.320743e-001, 2.200053e-002
9846, -1.086353e-001, 1.330605e-001, 2.200054e-002
9847, -1.075673e-001, 1.271426e-001, 2.200055e-002
9848, -1.077448e-001, 1.281291e-001, 2.200054e-002
9849, -1.072103e-001, 1.251702e-001, 2.200054e-002
9850, -1.073877e-001, 1.261566e-001, 2.200053e-002
9851, -1.064976e-001, 1.212251e-001, 2.200054e-002
9852, -1.066746e-001, 1.222115e-001, 2.200053e-002
9853, -1.105952e-001, 1.439097e-001, 2.200054e-002
9854, -1.107732e-001, 1.448960e-001, 2.200054e-002
9855, -1.098826e-001, 1.399645e-001, 2.200054e-002
9856, -1.100602e-001, 1.409509e-001, 2.200053e-002
9857, -1.109507e-001, 1.458824e-001, 2.200053e-002
9858, -1.079222e-001, 1.291155e-001, 2.200053e-002
9859, -1.080996e-001, 1.301019e-001, 2.200052e-002
9860, -1.091693e-001, 1.360195e-001, 2.200053e-002
9861, -1.120103e-001, 1.518027e-001, 2.200041e-002
9862, -1.082772e-001, 1.310883e-001, 2.200051e-002
9863, -8.918686e-002, 2.555298e-002, 2.200024e-002
9864, -1.056070e-001, 1.162936e-001, 2.200055e-002
9865, -1.057847e-001, 1.172800e-001, 2.200054e-002
9866, -1.104163e-001, 1.429235e-001, 2.200053e-002
9867, -1.063191e-001, 1.202388e-001, 2.200054e-002
9868, -1.093469e-001, 1.370059e-001, 2.200052e-002
9869, -1.095252e-001, 1.379921e-001, 2.200052e-002
9870, -1.059626e-001, 1.182663e-001, 2.200054e-002
9871, -1.061405e-001, 1.192526e-001, 2.200053e-002
9872, -1.121819e-001, 1.527915e-001, 2.200033e-002
9873, -1.052508e-001, 1.143210e-001, 2.200055e-002
9874, -1.054280e-001, 1.153074e-001, 2.200054e-002
9875, -1.050721e-001, 1.133348e-001, 2.200054e-002
9876, -1.048937e-001, 1.123485e-001, 2.200054e-002
9877, -1.047153e-001, 1.113623e-001, 2.200054e-002
9878, -1.045371e-001, 1.103760e-001, 2.200053e-002
9879, -1.043588e-001, 1.093897e-001, 2.200053e-002
9880, -1.041806e-001, 1.084034e-001, 2.200053e-002
9881, -1.040024e-001, 1.074172e-001, 2.200053e-002
9882, -1.038242e-001, 1.064309e-001, 2.200053e-002
9883, -1.036461e-001, 1.054446e-001, 2.200053e-002
9884, -1.034679e-001, 1.044583e-001, 2.200053e-002
9885, -1.032897e-001, 1.034720e-001, 2.200053e-002
9886, -1.031115e-001, 1.024857e-001, 2.200053e-002
9887, -1.029334e-001, 1.014995e-001, 2.200053e-002
9888, -1.027552e-001, 1.005132e-001, 2.200053e-002
9889, -1.025770e-001, 9.952689e-002, 2.200053e-002
9890, -1.023989e-001, 9.854061e-002, 2.200053e-002
9891, -1.022207e-001, 9.755432e-002, 2.200053e-002
9892, -1.020425e-001, 9.656804e-002, 2.200053e-002
9893, -1.018643e-001, 9.558175e-002, 2.200053e-002
9894, -1.016862e-001, 9.459547e-002, 2.200053e-002
9895, -1.015080e-001, 9.360919e-002, 2.200053e-002
9896, -1.013298e-001, 9.262290e-002, 2.200053e-002
9897, -1.011517e-001, 9.163662e-002, 2.200053e-002
9898, -1.009735e-001, 9.065033e-002, 2.200053e-002
9899, -1.007953e-001, 8.966405e-002, 2.200053e-002
9900, -1.006171e-001, 8.867777e-002, 2.200053e-002
9901, -1.004390e-001, 8.769148e-002, 2.200053e-002
9902, -1.002608e-001, 8.670520e-002, 2.200053e-002
9903, -1.000826e-001, 8.571891e-002, 2.200053e-002
9904, -9.990444e-002, 8.473263e-002, 2.200053e-002
9905, -9.972627e-002, 8.374634e-002, 2.200053e-002
9906, -9.954810e-002, 8.276006e-002, 2.200053e-002
9907, -9.936992e-002, 8.177378e-002, 2.200053e-002
9908, -9.919175e-002, 8.078749e-002, 2.200053e-002
9909, -9.901358e-002, 7.980121e-002, 2.200053e-002
9910, -9.883541e-002, 7.881492e-002, 2.200053e-002
9911, -9.865723e-002, 7.782864e-002, 2.200053e-002
9912, -9.847906e-002, 7.684236e-002, 2.200053e-002
9913, -9.830089e-002, 7.585607e-002, 2.200053e-002
9914, -9.812272e-002, 7.486979e-002, 2.200053e-002
9915, -9.794454e-002, 7.388350e-002, 2.200053e-002
9916, -9.776637e-002, 7.289722e-002, 2.200053e-002
9917, -9.758820e-002, 7.191093e-002, 2.200053e-002
9918, -9.741003e-002, 7.092465e-002, 2.200053e-002
9919, -9.723185e-002, 6.993837e-002, 2.200053e-002
9920, -9.705368e-002, 6.895208e-002, 2.200053e-002
9921, -9.687551e-002, 6.796580e-002, 2.200053e-002
9922, -9.669734e-002, 6.697951e-002, 2.200053e-002
9923, -9.651916e-002, 6.599323e-002, 2.200053e-002
9924, -9.634099e-002, 6.500695e-002, 2.200053e-002
9925, -9.616282e-002, 6.402066e-002, 2.200053e-002
9926, -9.598465e-002, 6.303438e-002, 2.200053e-002
9927, -9.580647e-002, 6.204809e-002, 2.200053e-002
9928, -9.562830e-002, 6.106181e-002, 2.200053e-002
9929, -9.545013e-002, 6.007552e-002, 2.200053e-002
9930, -9.527196e-002, 5.908924e-002, 2.200053e-002
9931, -9.509378e-002, 5.810296e-002, 2.200053e-002
9932, -9.491561e-002, 5.711667e-002, 2.200053e-002
9933, -9.473744e-002, 5.613039e-002, 2.200053e-002
9934, -9.455927e-002, 5.514410e-002, 2.200053e-002
9935, -9.438109e-002, 5.415782e-002, 2.200053e-002
9936, -9.420292e-002, 5.317154e-002, 2.200053e-002
9937, -9.402475e-002, 5.218525e-002, 2.200053e-002
9938, -9.384657e-002, 5.119897e-002, 2.200053e-002
9939, -9.366840e-002, 5.021268e-002, 2.200053e-002
9940, -9.349023e-002, 4.922640e-002, 2.200053e-002
9941, -9.331206e-002, 4.824012e-002, 2.200053e-002
9942, -9.313388e-002, 4.725383e-002, 2.200053e-002
9943, -9.295571e-002, 4.626755e-002, 2.200053e-002
9944, -9.277754e-002, 4.528126e-002, 2.200053e-002
9945, -9.259937e-002, 4.429498e-002, 2.200053e-002
9946, -9.242119e-002, 4.330869e-002, 2.200053e-002
9947, -9.224302e-002, 4.232241e-002, 2.200053e-002
9948, -9.206485e-002, 4.133613e-002, 2.200053e-002
9949, -9.188668e-002, 4.034984e-002, 2.200053e-002
9950, -9.170850e-002, 3.936356e-002, 2.200053e-002
9951, -9.153033e-002, 3.837727e-002, 2.200053e-002
9952, -9.135216e-002, 3.739099e-002, 2.200053e-002
9953, -9.117399e-002, 3.640471e-002, 2.200053e-002
9954, -9.099581e-002, 3.541842e-002, 2.200053e-002
9955, -9.081764e-002, 3.443214e-002, 2.200053e-002
9956, -9.063947e-002, 3.344585e-002, 2.200053e-002
9957, -9.046130e-002, 3.245957e-002, 2.200053e-002
9958, -9.028311e-002, 3.147328e-002, 2.200053e-002
9959, -9.010469e-002, 3.048701e-002, 2.200053e-002
9960, -8.992532e-002, 2.950076e-002, 2.200051e-002
9961, -8.974401e-002, 2.851443e-002, 2.200047e-002
9962, -8.956013e-002, 2.752782e-002, 2.200041e-002
9963, -8.937393e-002, 2.654074e-002, 2.200032e-002
9964, -1.113070e-001, 1.478550e-001, 2.200053e-002
9965, -1.111279e-001, 1.468688e-001, 2.200051e-002
9966, -1.102376e-001, 1.419373e-001, 2.200052e-002
9967, -1.123525e-001, 1.537820e-001, 2.200025e-002
9968, -1.097035e-001, 1.389784e-001, 2.200053e-002
9969, -1.070313e-001, 1.241840e-001, 2.200053e-002
9970, -1.068520e-001, 1.231980e-001, 2.200052e-002
9971, -1.208585e-001, 2.067503e-001, 2.241079e-002
9972, -1.198828e-001, 2.067703e-001, 2.222011e-002
9973, -1.189433e-001, 2.066846e-001, 2.190847e-002
9974, -1.180656e-001, 2.064958e-001, 2.148468e-002
9975, -1.172728e-001, 2.062090e-001, 2.095999e-002
9976, -1.165864e-001, 2.058317e-001, 2.034838e-002
9977, -1.160258e-001, 2.053745e-001, 1.966699e-002
9978, -1.156066e-001, 2.048502e-001, 1.893495e-002
9979, -1.153402e-001, 2.042737e-001, 1.817272e-002
9980, -1.152333e-001, 2.036608e-001, 1.740138e-002
9981, -1.152883e-001, 2.030284e-001, 1.664199e-002
9982, -1.155031e-001, 2.023938e-001, 1.591504e-002
9983, -1.158714e-001, 2.017738e-001, 1.523988e-002
9984, -1.163834e-001, 2.011850e-001, 1.463443e-002
9985, -1.170253e-001, 2.006431e-001, 1.411472e-002
9986, -1.177806e-001, 2.001623e-001, 1.369461e-002
9987, -1.186282e-001, 1.997564e-001, 1.338613e-002
9988, -1.195444e-001, 1.994365e-001, 1.319780e-002
9989, -1.205042e-001, 1.992113e-001, 1.313452e-002
9990, -1.214820e-001, 1.990866e-001, 1.319783e-002
9991, -1.224516e-001, 1.990657e-001, 1.338606e-002
9992, -1.233871e-001, 1.991493e-001, 1.369432e-002
9993, -1.242630e-001, 1.993354e-001, 1.411444e-002
9994, -1.250547e-001, 1.996187e-001, 1.463466e-002
9995, -1.257405e-001, 1.999914e-001, 1.524043e-002
9996, -1.263025e-001, 2.004433e-001, 1.591568e-002
9997, -1.267255e-001, 2.009627e-001, 1.664251e-002
9998, -1.269981e-001, 2.015356e-001, 1.740159e-002
9999, -1.271123e-001, 2.021469e-001, 1.817255e-002
10000, -1.270646e-001, 2.027800e-001, 1.893445e-002
10001, -1.268555e-001, 2.034176e-001, 1.966634e-002
10002, -1.264904e-001, 2.040421e-001, 2.034783e-002
10003, -1.259792e-001, 2.046360e-001, 2.095980e-002
10004, -1.253361e-001, 2.051827e-001, 2.148503e-002
10005, -1.245796e-001, 2.056667e-001, 2.190887e-002
10006, -1.237298e-001, 2.060755e-001, 2.222028e-002
10007, -1.228091e-001, 2.063980e-001, 2.241083e-002
10008, -1.207160e-001, 2.059733e-001, 2.303495e-002
10009, -1.205722e-001, 2.051845e-001, 2.364378e-002
10010, -1.204269e-001, 2.043842e-001, 2.423702e-002
10011, -1.202799e-001, 2.035727e-001, 2.481439e-002
10012, -1.201307e-001, 2.027504e-001, 2.537560e-002
10013, -1.199796e-001, 2.019176e-001, 2.592052e-002
10014, -1.198266e-001, 2.010744e-001, 2.644898e-002
10015, -1.196719e-001, 2.002212e-001, 2.696076e-002
10016, -1.195157e-001, 1.993584e-001, 2.745565e-002
10017, -1.193580e-001, 1.984864e-001, 2.793346e-002
10018, -1.191987e-001, 1.976054e-001, 2.839400e-002
10019, -1.190380e-001, 1.967157e-001, 2.883710e-002
10020, -1.188758e-001, 1.958178e-001, 2.926260e-002
10021, -1.187121e-001, 1.949119e-001, 2.967032e-002
10022, -1.185471e-001, 1.939984e-001, 3.006012e-002
10023, -1.183808e-001, 1.930776e-001, 3.043184e-002
10024, -1.182132e-001, 1.921499e-001, 3.078535e-002
10025, -1.180445e-001, 1.912157e-001, 3.112051e-002
10026, -1.178746e-001, 1.902752e-001, 3.143720e-002
10027, -1.177036e-001, 1.893288e-001, 3.173529e-002
10028, -1.175317e-001, 1.883770e-001, 3.201468e-002
10029, -1.173588e-001, 1.874200e-001, 3.227526e-002
10030, -1.171851e-001, 1.864582e-001, 3.251693e-002
10031, -1.170106e-001, 1.854920e-001, 3.273960e-002
10032, -1.168353e-001, 1.845217e-001, 3.294319e-002
10033, -1.166594e-001, 1.835477e-001, 3.312761e-002
10034, -1.164829e-001, 1.825704e-001, 3.329281e-002
10035, -1.163058e-001, 1.815902e-001, 3.343873e-002
10036, -1.161283e-001, 1.806074e-001, 3.356529e-002
10037, -1.159507e-001, 1.796225e-001, 3.367249e-002
10038, -1.157731e-001, 1.786356e-001, 3.376033e-002
10039, -1.155955e-001, 1.776470e-001, 3.382879e-002
10040, -1.154184e-001, 1.766570e-001, 3.387788e-002
10041, -1.152422e-001, 1.756660e-001, 3.390764e-002
10042, -1.142925e-001, 1.758329e-001, 3.366239e-002
10043, -1.133963e-001, 1.759874e-001, 3.326174e-002
10044, -1.125781e-001, 1.761256e-001, 3.271727e-002
10045, -1.118592e-001, 1.762440e-001, 3.204369e-002
10046, -1.112582e-001, 1.763402e-001, 3.125768e-002
10047, -1.107928e-001, 1.764108e-001, 3.038168e-002
10048, -1.104762e-001, 1.764532e-001, 2.944066e-002
10049, -1.103164e-001, 1.764654e-001, 2.846109e-002
10050, -1.103173e-001, 1.764469e-001, 2.747033e-002
10051, -1.104781e-001, 1.763981e-001, 2.649539e-002
10052, -1.107936e-001, 1.763206e-001, 2.556234e-002
10053, -1.112551e-001, 1.762169e-001, 2.469578e-002
10054, -1.118506e-001, 1.760909e-001, 2.391833e-002
10055, -1.125664e-001, 1.759496e-001, 2.324981e-002
10056, -1.133815e-001, 1.757952e-001, 2.271007e-002
10057, -1.142728e-001, 1.756303e-001, 2.231428e-002
10058, -1.152155e-001, 1.754584e-001, 2.207288e-002
10059, -1.161842e-001, 1.752834e-001, 2.199204e-002
10060, -1.171529e-001, 1.751097e-001, 2.207378e-002
10061, -1.180960e-001, 1.749417e-001, 2.231603e-002
10062, -1.189882e-001, 1.747844e-001, 2.271261e-002
10063, -1.198053e-001, 1.746433e-001, 2.325316e-002
10064, -1.205246e-001, 1.745242e-001, 2.392257e-002
10065, -1.211258e-001, 1.744334e-001, 2.470068e-002
10066, -1.215936e-001, 1.743699e-001, 2.556747e-002
10067, -1.219156e-001, 1.743338e-001, 2.650036e-002
10068, -1.220827e-001, 1.743253e-001, 2.747487e-002
10069, -1.220896e-001, 1.743442e-001, 2.846511e-002
10070, -1.219353e-001, 1.743898e-001, 2.944422e-002
10071, -1.216232e-001, 1.744611e-001, 3.038512e-002
10072, -1.211616e-001, 1.745569e-001, 3.126113e-002
10073, -1.205639e-001, 1.746759e-001, 3.204711e-002
10074, -1.198484e-001, 1.748159e-001, 3.272007e-002
10075, -1.190338e-001, 1.749719e-001, 3.326346e-002
10076, -1.181407e-001, 1.751395e-001, 3.366322e-002
10077, -1.171937e-001, 1.753143e-001, 3.390785e-002
10078, -1.226700e-001, 2.056204e-001, 2.303508e-002
10079, -1.225279e-001, 2.048314e-001, 2.364403e-002
10080, -1.223834e-001, 2.040310e-001, 2.423736e-002
10081, -1.222368e-001, 2.032194e-001, 2.481482e-002
10082, -1.220882e-001, 2.023970e-001, 2.537618e-002
10083, -1.219377e-001, 2.015640e-001, 2.592123e-002
10084, -1.217854e-001, 2.007208e-001, 2.644977e-002
10085, -1.216313e-001, 1.998676e-001, 2.696159e-002
10086, -1.214754e-001, 1.990049e-001, 2.745651e-002
10087, -1.213179e-001, 1.981328e-001, 2.793434e-002
10088, -1.211588e-001, 1.972518e-001, 2.839490e-002
10089, -1.209981e-001, 1.963621e-001, 2.883801e-002
10090, -1.208359e-001, 1.954641e-001, 2.926351e-002
10091, -1.206722e-001, 1.945582e-001, 2.967124e-002
10092, -1.205072e-001, 1.936447e-001, 3.006104e-002
10093, -1.203409e-001, 1.927239e-001, 3.043277e-002
10094, -1.201733e-001, 1.917962e-001, 3.078628e-002
10095, -1.200046e-001, 1.908619e-001, 3.112144e-002
10096, -1.198347e-001, 1.899214e-001, 3.143813e-002
10097, -1.196637e-001, 1.889750e-001, 3.173623e-002
10098, -1.194918e-001, 1.880231e-001, 3.201561e-002
10099, -1.193189e-001, 1.870661e-001, 3.227619e-002
10100, -1.191452e-001, 1.861043e-001, 3.251786e-002
10101, -1.189707e-001, 1.851381e-001, 3.274053e-002
10102, -1.187954e-001, 1.841678e-001, 3.294411e-002
10103, -1.186195e-001, 1.831938e-001, 3.312854e-002
10104, -1.184429e-001, 1.822165e-001, 3.329373e-002
10105, -1.182659e-001, 1.812365e-001, 3.343960e-002
10106, -1.180886e-001, 1.802547e-001, 3.356604e-002
10107, -1.179108e-001, 1.792710e-001, 3.367311e-002
10108, -1.177325e-001, 1.782846e-001, 3.376089e-002
10109, -1.175537e-001, 1.772958e-001, 3.382929e-002
10110, -1.173742e-001, 1.763053e-001, 3.387827e-002
10111, -1.197392e-001, 2.059967e-001, 2.284055e-002
10112, -1.188000e-001, 2.059165e-001, 2.252318e-002
10113, -1.179236e-001, 2.057352e-001, 2.209198e-002
10114, -1.171325e-001, 2.054576e-001, 2.155810e-002
10115, -1.164479e-001, 2.050909e-001, 2.093530e-002
10116, -1.158899e-001, 2.046453e-001, 2.024137e-002
10117, -1.154743e-001, 2.041337e-001, 1.949623e-002
10118, -1.152122e-001, 2.035707e-001, 1.872111e-002
10119, -1.151101e-001, 2.029722e-001, 1.793773e-002
10120, -1.151697e-001, 2.023548e-001, 1.716752e-002
10121, -1.153885e-001, 2.017351e-001, 1.643105e-002
10122, -1.157599e-001, 2.011295e-001, 1.574759e-002
10123, -1.162738e-001, 2.005539e-001, 1.513484e-002
10124, -1.169170e-001, 2.000232e-001, 1.460866e-002
10125, -1.176736e-001, 1.995512e-001, 1.418284e-002
10126, -1.185220e-001, 1.991518e-001, 1.387017e-002
10127, -1.194379e-001, 1.988363e-001, 1.367938e-002
10128, -1.203964e-001, 1.986129e-001, 1.361530e-002
10129, -1.213722e-001, 1.984872e-001, 1.367937e-002
10130, -1.223396e-001, 1.984624e-001, 1.386992e-002
10131, -1.232730e-001, 1.985395e-001, 1.418219e-002
10132, -1.241471e-001, 1.987168e-001, 1.460804e-002
10133, -1.249368e-001, 1.989893e-001, 1.513524e-002
10134, -1.256200e-001, 1.993490e-001, 1.574864e-002
10135, -1.261797e-001, 1.997865e-001, 1.643230e-002
10136, -1.266011e-001, 2.002904e-001, 1.716852e-002
10137, -1.268727e-001, 2.008476e-001, 1.793813e-002
10138, -1.269863e-001, 2.014436e-001, 1.872076e-002
10139, -1.269380e-001, 2.020622e-001, 1.949524e-002
10140, -1.267279e-001, 2.026866e-001, 2.024010e-002
10141, -1.263612e-001, 2.032994e-001, 2.093426e-002
10142, -1.258479e-001, 2.038830e-001, 2.155776e-002
10143, -1.252025e-001, 2.044208e-001, 2.209271e-002
10144, -1.244443e-001, 2.048975e-001, 2.252400e-002
10145, -1.235928e-001, 2.053009e-001, 2.284098e-002
10146, -1.183217e-001, 1.761272e-001, 3.363307e-002
10147, -1.193036e-001, 2.036074e-001, 2.461064e-002
10148, -1.194500e-001, 2.044150e-001, 2.403616e-002
10149, -1.191541e-001, 2.027892e-001, 2.516864e-002
10150, -1.190029e-001, 2.019604e-001, 2.571056e-002
10151, -1.188499e-001, 2.011211e-001, 2.623625e-002
10152, -1.186951e-001, 2.002718e-001, 2.674538e-002
10153, -1.185391e-001, 1.994130e-001, 2.723776e-002
10154, -1.183819e-001, 1.985450e-001, 2.771324e-002
10155, -1.182233e-001, 1.976682e-001, 2.817155e-002
10156, -1.180633e-001, 1.967828e-001, 2.861252e-002
10157, -1.179019e-001, 1.958892e-001, 2.903599e-002
10158, -1.177390e-001, 1.949876e-001, 2.944178e-002
10159, -1.175748e-001, 1.940784e-001, 2.982973e-002
10160, -1.174093e-001, 1.931621e-001, 3.019969e-002
10161, -1.172426e-001, 1.922388e-001, 3.055152e-002
10162, -1.170746e-001, 1.913090e-001, 3.088510e-002
10163, -1.169056e-001, 1.903730e-001, 3.120029e-002
10164, -1.167355e-001, 1.894311e-001, 3.149697e-002
10165, -1.165644e-001, 1.884838e-001, 3.177504e-002
10166, -1.163924e-001, 1.875314e-001, 3.203438e-002
10167, -1.162195e-001, 1.865742e-001, 3.227490e-002
10168, -1.160458e-001, 1.856126e-001, 3.249652e-002
10169, -1.158714e-001, 1.846469e-001, 3.269914e-002
10170, -1.156964e-001, 1.836776e-001, 3.288269e-002
10171, -1.155207e-001, 1.827050e-001, 3.304710e-002
10172, -1.153446e-001, 1.817296e-001, 3.319232e-002
10173, -1.151683e-001, 1.807519e-001, 3.331832e-002
10174, -1.149921e-001, 1.797722e-001, 3.342517e-002
10175, -1.148161e-001, 1.787904e-001, 3.351295e-002
10176, -1.146405e-001, 1.778063e-001, 3.358167e-002
10177, -1.144655e-001, 1.768202e-001, 3.363139e-002
10178, -1.135671e-001, 1.769682e-001, 3.322929e-002
10179, -1.127473e-001, 1.770979e-001, 3.268354e-002
10180, -1.120271e-001, 1.772064e-001, 3.200875e-002
10181, -1.114244e-001, 1.772916e-001, 3.122079e-002
10182, -1.109576e-001, 1.773506e-001, 3.034214e-002
10183, -1.106401e-001, 1.773800e-001, 2.939895e-002
10184, -1.104800e-001, 1.773772e-001, 2.841843e-002
10185, -1.104803e-001, 1.773417e-001, 2.742849e-002
10186, -1.106397e-001, 1.772744e-001, 2.645594e-002
10187, -1.109530e-001, 1.771774e-001, 2.552611e-002
10188, -1.114114e-001, 1.770541e-001, 2.466287e-002
10189, -1.120038e-001, 1.769102e-001, 2.388825e-002
10190, -1.127179e-001, 1.767579e-001, 2.322122e-002
10191, -1.135324e-001, 1.765975e-001, 2.268264e-002
10192, -1.144228e-001, 1.764297e-001, 2.228807e-002
10193, -1.153641e-001, 1.762568e-001, 2.204776e-002
10194, -1.163310e-001, 1.760823e-001, 2.196758e-002
10195, -1.172980e-001, 1.759099e-001, 2.204939e-002
10196, -1.182399e-001, 1.757443e-001, 2.229121e-002
10197, -1.191320e-001, 1.755906e-001, 2.268720e-002
10198, -1.199501e-001, 1.754549e-001, 2.322727e-002
10199, -1.206712e-001, 1.753458e-001, 2.389592e-002
10200, -1.212748e-001, 1.752734e-001, 2.467125e-002
10201, -1.217461e-001, 1.752312e-001, 2.553437e-002
10202, -1.220726e-001, 1.752171e-001, 2.646369e-002
10203, -1.222451e-001, 1.752299e-001, 2.743562e-002
10204, -1.222575e-001, 1.752680e-001, 2.842493e-002
10205, -1.221078e-001, 1.753296e-001, 2.940512e-002
10206, -1.217987e-001, 1.754134e-001, 3.034848e-002
10207, -1.213387e-001, 1.755188e-001, 3.122717e-002
10208, -1.207416e-001, 1.756457e-001, 3.201538e-002
10209, -1.200276e-001, 1.757925e-001, 3.268885e-002
10210, -1.192147e-001, 1.759546e-001, 3.323244e-002
10211, -1.234515e-001, 2.045155e-001, 2.344691e-002
10212, -1.233077e-001, 2.037189e-001, 2.403742e-002
10213, -1.231616e-001, 2.029113e-001, 2.461217e-002
10214, -1.230137e-001, 2.020928e-001, 2.517089e-002
10215, -1.228639e-001, 2.012638e-001, 2.571336e-002
10216, -1.227122e-001, 2.004246e-001, 2.623940e-002
10217, -1.225588e-001, 1.995754e-001, 2.674881e-002
10218, -1.224037e-001, 1.987167e-001, 2.724139e-002
10219, -1.222470e-001, 1.978488e-001, 2.771696e-002
10220, -1.220886e-001, 1.969719e-001, 2.817533e-002
10221, -1.219287e-001, 1.960864e-001, 2.861635e-002
10222, -1.217673e-001, 1.951927e-001, 2.903984e-002
10223, -1.216044e-001, 1.942910e-001, 2.944564e-002
10224, -1.214402e-001, 1.933818e-001, 2.983360e-002
10225, -1.212747e-001, 1.924653e-001, 3.020357e-002
10226, -1.211079e-001, 1.915419e-001, 3.055541e-002
10227, -1.209400e-001, 1.906120e-001, 3.088899e-002
10228, -1.207709e-001, 1.896760e-001, 3.120418e-002
10229, -1.206008e-001, 1.887340e-001, 3.150086e-002
10230, -1.204297e-001, 1.877866e-001, 3.177892e-002
10231, -1.202576e-001, 1.868341e-001, 3.203826e-002
10232, -1.200847e-001, 1.858768e-001, 3.227877e-002
10233, -1.199111e-001, 1.849152e-001, 3.250037e-002
10234, -1.197366e-001, 1.839494e-001, 3.270298e-002
10235, -1.195616e-001, 1.829800e-001, 3.288652e-002
10236, -1.193859e-001, 1.820074e-001, 3.305092e-002
10237, -1.192098e-001, 1.810333e-001, 3.319597e-002
10238, -1.190339e-001, 1.800588e-001, 3.332147e-002
10239, -1.188574e-001, 1.790822e-001, 3.342787e-002
10240, -1.186800e-001, 1.781006e-001, 3.351535e-002
10241, -1.185017e-001, 1.771149e-001, 3.358370e-002
10242, -1.195949e-001, 2.052115e-001, 2.344598e-002
10243, -1.186566e-001, 2.051371e-001, 2.312342e-002
10244, -1.177819e-001, 2.049638e-001, 2.268546e-002
10245, -1.169928e-001, 2.046963e-001, 2.214311e-002
10246, -1.163102e-001, 2.043412e-001, 2.150997e-002
10247, -1.157546e-001, 2.039083e-001, 2.080438e-002
10248, -1.153420e-001, 2.034104e-001, 2.004694e-002
10249, -1.150835e-001, 2.028617e-001, 1.925954e-002
10250, -1.149853e-001, 2.022780e-001, 1.846445e-002
10251, -1.150488e-001, 2.016755e-001, 1.768342e-002
10252, -1.152708e-001, 2.010706e-001, 1.693718e-002
10253, -1.156448e-001, 2.004789e-001, 1.624497e-002
10254, -1.161606e-001, 1.999158e-001, 1.562443e-002
10255, -1.168052e-001, 1.993957e-001, 1.509134e-002
10256, -1.175634e-001, 1.989322e-001, 1.465940e-002
10257, -1.184129e-001, 1.985393e-001, 1.434218e-002
10258, -1.193291e-001, 1.982279e-001, 1.414870e-002
10259, -1.202870e-001, 1.980061e-001, 1.408374e-002
10260, -1.212616e-001, 1.978792e-001, 1.414867e-002
10261, -1.222275e-001, 1.978506e-001, 1.434178e-002
10262, -1.231594e-001, 1.979214e-001, 1.465837e-002
10263, -1.240320e-001, 1.980901e-001, 1.509031e-002
10264, -1.248197e-001, 1.983520e-001, 1.562492e-002
10265, -1.255005e-001, 1.986994e-001, 1.624639e-002
10266, -1.260577e-001, 1.991231e-001, 1.693889e-002
10267, -1.264769e-001, 1.996120e-001, 1.768481e-002
10268, -1.267467e-001, 2.001538e-001, 1.846504e-002
10269, -1.268588e-001, 2.007343e-001, 1.925913e-002
10270, -1.268088e-001, 2.013382e-001, 2.004571e-002
10271, -1.265969e-001, 2.019486e-001, 2.080282e-002
10272, -1.262281e-001, 2.025486e-001, 2.150874e-002
10273, -1.257123e-001, 2.031210e-001, 2.214283e-002
10274, -1.250648e-001, 2.036491e-001, 2.268662e-002
10275, -1.243050e-001, 2.041177e-001, 2.312472e-002
10276, -1.179142e-001, 2.010784e-001, 2.588901e-002
10277, -1.180665e-001, 2.019115e-001, 2.536771e-002
10278, -1.183666e-001, 2.035456e-001, 2.427807e-002
10279, -1.185119e-001, 2.043467e-001, 2.370837e-002
10280, -1.182170e-001, 2.027339e-001, 2.483061e-002
10281, -1.177594e-001, 2.002352e-001, 2.639364e-002
10282, -1.176039e-001, 1.993827e-001, 2.688184e-002
10283, -1.174479e-001, 1.985214e-001, 2.735356e-002
10284, -1.172903e-001, 1.976514e-001, 2.780817e-002
10285, -1.171314e-001, 1.967730e-001, 2.824562e-002
10286, -1.169713e-001, 1.958863e-001, 2.866579e-002
10287, -1.168099e-001, 1.949919e-001, 2.906845e-002
10288, -1.166470e-001, 1.940899e-001, 2.945336e-002
10289, -1.164828e-001, 1.931807e-001, 2.982044e-002
10290, -1.163174e-001, 1.922646e-001, 3.016954e-002
10291, -1.161508e-001, 1.913421e-001, 3.050051e-002
10292, -1.159831e-001, 1.904134e-001, 3.081325e-002
10293, -1.158143e-001, 1.894790e-001, 3.110762e-002
10294, -1.156446e-001, 1.885391e-001, 3.138352e-002
10295, -1.154740e-001, 1.875942e-001, 3.164085e-002
10296, -1.153025e-001, 1.866445e-001, 3.187951e-002
10297, -1.151302e-001, 1.856904e-001, 3.209940e-002
10298, -1.149571e-001, 1.847324e-001, 3.230043e-002
10299, -1.147835e-001, 1.837708e-001, 3.248252e-002
10300, -1.146094e-001, 1.828063e-001, 3.264563e-002
10301, -1.144349e-001, 1.818391e-001, 3.278973e-002
10302, -1.142605e-001, 1.808699e-001, 3.291493e-002
10303, -1.140865e-001, 1.798989e-001, 3.302139e-002
10304, -1.139129e-001, 1.789253e-001, 3.310922e-002
10305, -1.137394e-001, 1.779483e-001, 3.317841e-002
10306, -1.129180e-001, 1.780699e-001, 3.263170e-002
10307, -1.115929e-001, 1.782455e-001, 3.116731e-002
10308, -1.121960e-001, 1.781697e-001, 3.195548e-002
10309, -1.111251e-001, 1.782959e-001, 3.028722e-002
10310, -1.108072e-001, 1.783157e-001, 2.934383e-002
10311, -1.106463e-001, 1.783015e-001, 2.836393e-002
10312, -1.106453e-001, 1.782521e-001, 2.737588e-002
10313, -1.108025e-001, 1.781684e-001, 2.640581e-002
10314, -1.111127e-001, 1.780540e-001, 2.547844e-002
10315, -1.115681e-001, 1.779129e-001, 2.461698e-002
10316, -1.121581e-001, 1.777528e-001, 2.384339e-002
10317, -1.128710e-001, 1.775900e-001, 2.317690e-002
10318, -1.136849e-001, 1.774236e-001, 2.263874e-002
10319, -1.145748e-001, 1.772522e-001, 2.224472e-002
10320, -1.155153e-001, 1.770778e-001, 2.200501e-002
10321, -1.164812e-001, 1.769033e-001, 2.192522e-002
10322, -1.174473e-001, 1.767325e-001, 2.200711e-002
10323, -1.183888e-001, 1.765696e-001, 2.224874e-002
10324, -1.192811e-001, 1.764199e-001, 2.264446e-002
10325, -1.201003e-001, 1.762904e-001, 2.318428e-002
10326, -1.208233e-001, 1.761918e-001, 2.385229e-002
10327, -1.214297e-001, 1.761381e-001, 2.462535e-002
10328, -1.219045e-001, 1.761175e-001, 2.548542e-002
10329, -1.222353e-001, 1.761255e-001, 2.641165e-002
10330, -1.224124e-001, 1.761596e-001, 2.738118e-002
10331, -1.224293e-001, 1.762161e-001, 2.836982e-002
10332, -1.222827e-001, 1.762917e-001, 2.935140e-002
10333, -1.219751e-001, 1.763842e-001, 3.029678e-002
10334, -1.215162e-001, 1.764938e-001, 3.117598e-002
10335, -1.209198e-001, 1.766243e-001, 3.196491e-002
10336, -1.202062e-001, 1.767732e-001, 3.263892e-002
10337, -1.193942e-001, 1.769387e-001, 3.318276e-002
10338, -1.241619e-001, 2.033274e-001, 2.371075e-002
10339, -1.240168e-001, 2.025262e-001, 2.428116e-002
10340, -1.238698e-001, 2.017143e-001, 2.483561e-002
10341, -1.237210e-001, 2.008919e-001, 2.537393e-002
10342, -1.235705e-001, 2.000592e-001, 2.589596e-002
10343, -1.234182e-001, 1.992166e-001, 2.640146e-002
10344, -1.232643e-001, 1.983645e-001, 2.689023e-002
10345, -1.231088e-001, 1.975033e-001, 2.736211e-002
10346, -1.229516e-001, 1.966332e-001, 2.781693e-002
10347, -1.227929e-001, 1.957546e-001, 2.825452e-002
10348, -1.226328e-001, 1.948678e-001, 2.867472e-002
10349, -1.224712e-001, 1.939731e-001, 2.907737e-002
10350, -1.223083e-001, 1.930709e-001, 2.946232e-002
10351, -1.221440e-001, 1.921615e-001, 2.982941e-002
10352, -1.219786e-001, 1.912453e-001, 3.017852e-002
10353, -1.218119e-001, 1.903225e-001, 3.050950e-002
10354, -1.216442e-001, 1.893937e-001, 3.082224e-002
10355, -1.214754e-001, 1.884591e-001, 3.111660e-002
10356, -1.213056e-001, 1.875190e-001, 3.139250e-002
10357, -1.211349e-001, 1.865738e-001, 3.164981e-002
10358, -1.209634e-001, 1.856240e-001, 3.188844e-002
10359, -1.207911e-001, 1.846698e-001, 3.210831e-002
10360, -1.206180e-001, 1.837115e-001, 3.230932e-002
10361, -1.204442e-001, 1.827493e-001, 3.249150e-002
10362, -1.202694e-001, 1.817845e-001, 3.265490e-002
10363, -1.200941e-001, 1.808211e-001, 3.279901e-002
10364, -1.199215e-001, 1.798602e-001, 3.292236e-002
10365, -1.197479e-001, 1.788954e-001, 3.302729e-002
10366, -1.195721e-001, 1.779210e-001, 3.311424e-002
10367, -1.176391e-001, 2.041818e-001, 2.326387e-002
10368, -1.168520e-001, 2.039250e-001, 2.271323e-002
10369, -1.161717e-001, 2.035822e-001, 2.207017e-002
10370, -1.156186e-001, 2.031628e-001, 2.135363e-002
10371, -1.152090e-001, 2.026790e-001, 2.058472e-002
10372, -1.149538e-001, 2.021451e-001, 1.978577e-002
10373, -1.148590e-001, 2.015765e-001, 1.897944e-002
10374, -1.149257e-001, 2.009892e-001, 1.818776e-002
10375, -1.151507e-001, 2.003990e-001, 1.743163e-002
10376, -1.155271e-001, 1.998211e-001, 1.673040e-002
10377, -1.160448e-001, 1.992704e-001, 1.610177e-002
10378, -1.166910e-001, 1.987608e-001, 1.556154e-002
10379, -1.174509e-001, 1.983057e-001, 1.512336e-002
10380, -1.183015e-001, 1.979191e-001, 1.480163e-002
10381, -1.192183e-001, 1.976115e-001, 1.460555e-002
10382, -1.201761e-001, 1.973909e-001, 1.453981e-002
10383, -1.211499e-001, 1.972628e-001, 1.460565e-002
10384, -1.221148e-001, 1.972305e-001, 1.480135e-002
10385, -1.230454e-001, 1.972951e-001, 1.512225e-002
10386, -1.239166e-001, 1.974554e-001, 1.556019e-002
10387, -1.247025e-001, 1.977070e-001, 1.610223e-002
10388, -1.253809e-001, 1.980423e-001, 1.673200e-002
10389, -1.259356e-001, 1.984523e-001, 1.743365e-002
10390, -1.263523e-001, 1.989264e-001, 1.818950e-002
10391, -1.266197e-001, 1.994527e-001, 1.898038e-002
10392, -1.267296e-001, 2.000177e-001, 1.978573e-002
10393, -1.266775e-001, 2.006063e-001, 2.058395e-002
10394, -1.264633e-001, 2.012023e-001, 2.135269e-002
10395, -1.260920e-001, 2.017888e-001, 2.206966e-002
10396, -1.255738e-001, 2.023491e-001, 2.271369e-002
10397, -1.249241e-001, 2.028668e-001, 2.326582e-002
10398, -1.174944e-001, 2.033896e-001, 2.382631e-002
10399, -1.168909e-001, 2.001130e-001, 2.591587e-002
10400, -1.170444e-001, 2.009482e-001, 2.541677e-002
10401, -1.203841e-001, 1.777532e-001, 3.256984e-002
10402, -1.173464e-001, 2.025868e-001, 2.437197e-002
10403, -1.165819e-001, 1.984166e-001, 2.686510e-002
10404, -1.167358e-001, 1.992688e-001, 2.639807e-002
10405, -1.164255e-001, 1.975558e-001, 2.731440e-002
10406, -1.162681e-001, 1.966867e-001, 2.774695e-002
10407, -1.161100e-001, 1.958097e-001, 2.816278e-002
10408, -1.159505e-001, 1.949249e-001, 2.856129e-002
10409, -1.157893e-001, 1.940325e-001, 2.894205e-002
10410, -1.156269e-001, 1.931331e-001, 2.930520e-002
10411, -1.154633e-001, 1.922270e-001, 2.965060e-002
10412, -1.152985e-001, 1.913144e-001, 2.997802e-002
10413, -1.151326e-001, 1.903957e-001, 3.028741e-002
10414, -1.149657e-001, 1.894713e-001, 3.057865e-002
10415, -1.147978e-001, 1.885416e-001, 3.085161e-002
10416, -1.146291e-001, 1.876068e-001, 3.110620e-002
10417, -1.144594e-001, 1.866673e-001, 3.134232e-002
10418, -1.142889e-001, 1.857234e-001, 3.155980e-002
10419, -1.141174e-001, 1.847758e-001, 3.175839e-002
10420, -1.139459e-001, 1.838257e-001, 3.193843e-002
10421, -1.137746e-001, 1.828735e-001, 3.209995e-002
10422, -1.136028e-001, 1.819187e-001, 3.224267e-002
10423, -1.134310e-001, 1.809615e-001, 3.236696e-002
10424, -1.132597e-001, 1.800016e-001, 3.247315e-002
10425, -1.130885e-001, 1.790383e-001, 3.256120e-002
10426, -1.109771e-001, 1.792588e-001, 2.927524e-002
10427, -1.112940e-001, 1.792440e-001, 3.021519e-002
10428, -1.108158e-001, 1.792389e-001, 2.829790e-002
10429, -1.117607e-001, 1.791987e-001, 3.109401e-002
10430, -1.123647e-001, 1.791289e-001, 3.188388e-002
10431, -1.108128e-001, 1.791806e-001, 2.731231e-002
10432, -1.109668e-001, 1.790841e-001, 2.634397e-002
10433, -1.112736e-001, 1.789554e-001, 2.541792e-002
10434, -1.117260e-001, 1.788004e-001, 2.455680e-002
10435, -1.123149e-001, 1.786281e-001, 2.378192e-002
10436, -1.130272e-001, 1.784551e-001, 2.311459e-002
10437, -1.138407e-001, 1.782810e-001, 2.257613e-002
10438, -1.147300e-001, 1.781044e-001, 2.218221e-002
10439, -1.156699e-001, 1.779270e-001, 2.194270e-002
10440, -1.166354e-001, 1.777520e-001, 2.186304e-002
10441, -1.176013e-001, 1.775830e-001, 2.194488e-002
10442, -1.185430e-001, 1.774242e-001, 2.218629e-002
10443, -1.194362e-001, 1.772808e-001, 2.258166e-002
10444, -1.202568e-001, 1.771601e-001, 2.312100e-002
10445, -1.209820e-001, 1.770739e-001, 2.378806e-002
10446, -1.215913e-001, 1.770379e-001, 2.455899e-002
10447, -1.220696e-001, 1.770375e-001, 2.541632e-002
10448, -1.224044e-001, 1.770666e-001, 2.633972e-002
10449, -1.225857e-001, 1.771205e-001, 2.730752e-002
10450, -1.226059e-001, 1.771932e-001, 2.829719e-002
10451, -1.224603e-001, 1.772796e-001, 2.928307e-002
10452, -1.221507e-001, 1.773739e-001, 3.023307e-002
10453, -1.216919e-001, 1.774747e-001, 3.110859e-002
10454, -1.210973e-001, 1.776030e-001, 3.189523e-002
10455, -1.171959e-001, 2.017729e-001, 2.490177e-002
10456, -1.247801e-001, 2.020747e-001, 2.383047e-002
10457, -1.246342e-001, 2.012719e-001, 2.437929e-002
10458, -1.244867e-001, 2.004585e-001, 2.491215e-002
10459, -1.243375e-001, 1.996347e-001, 2.542891e-002
10460, -1.241867e-001, 1.988010e-001, 2.592922e-002
10461, -1.240344e-001, 1.979579e-001, 2.641290e-002
10462, -1.238804e-001, 1.971058e-001, 2.687982e-002
10463, -1.237249e-001, 1.962450e-001, 2.732983e-002
10464, -1.235679e-001, 1.953757e-001, 2.776279e-002
10465, -1.234094e-001, 1.944983e-001, 2.817854e-002
10466, -1.232495e-001, 1.936131e-001, 2.857692e-002
10467, -1.230883e-001, 1.927205e-001, 2.895779e-002
10468, -1.229258e-001, 1.918208e-001, 2.932100e-002
10469, -1.227621e-001, 1.909143e-001, 2.966641e-002
10470, -1.225972e-001, 1.900014e-001, 2.999388e-002
10471, -1.224312e-001, 1.890824e-001, 3.030330e-002
10472, -1.222642e-001, 1.881577e-001, 3.059455e-002
10473, -1.220962e-001, 1.872276e-001, 3.086752e-002
10474, -1.219273e-001, 1.862925e-001, 3.112210e-002
10475, -1.217575e-001, 1.853527e-001, 3.135819e-002
10476, -1.215871e-001, 1.844087e-001, 3.157570e-002
10477, -1.214158e-001, 1.834600e-001, 3.177467e-002
10478, -1.212429e-001, 1.825065e-001, 3.195572e-002
10479, -1.210668e-001, 1.815521e-001, 3.211996e-002
10480, -1.208897e-001, 1.806065e-001, 3.226573e-002
10481, -1.207259e-001, 1.796685e-001, 3.238242e-002
10482, -1.205585e-001, 1.787200e-001, 3.248323e-002
10483, -1.167091e-001, 2.031437e-001, 2.326707e-002
10484, -1.160312e-001, 2.028134e-001, 2.261447e-002
10485, -1.154809e-001, 2.024074e-001, 2.188777e-002
10486, -1.150743e-001, 2.019380e-001, 2.110825e-002
10487, -1.148224e-001, 2.014192e-001, 2.029854e-002
10488, -1.147309e-001, 2.008662e-001, 1.948156e-002
10489, -1.148008e-001, 2.002944e-001, 1.867956e-002
10490, -1.150286e-001, 1.997193e-001, 1.791358e-002
10491, -1.154074e-001, 1.991555e-001, 1.720315e-002
10492, -1.159271e-001, 1.986174e-001, 1.656612e-002
10493, -1.165751e-001, 1.981186e-001, 1.601855e-002
10494, -1.173366e-001, 1.976716e-001, 1.557446e-002
10495, -1.181884e-001, 1.972907e-001, 1.524865e-002
10496, -1.191057e-001, 1.969866e-001, 1.505022e-002
10497, -1.200635e-001, 1.967671e-001, 1.498377e-002
10498, -1.210369e-001, 1.966378e-001, 1.505052e-002
10499, -1.220009e-001, 1.966018e-001, 1.524872e-002
10500, -1.229304e-001, 1.966605e-001, 1.557371e-002
10501, -1.238002e-001, 1.968128e-001, 1.601734e-002
10502, -1.245844e-001, 1.970542e-001, 1.656666e-002
10503, -1.252604e-001, 1.973771e-001, 1.720492e-002
10504, -1.258124e-001, 1.977731e-001, 1.791595e-002
10505, -1.262265e-001, 1.982322e-001, 1.868186e-002
10506, -1.264913e-001, 1.987429e-001, 1.948331e-002
10507, -1.265987e-001, 1.992921e-001, 2.029965e-002
10508, -1.265441e-001, 1.998652e-001, 2.110904e-002
10509, -1.263274e-001, 2.004464e-001, 2.188880e-002
10510, -1.259535e-001, 2.010192e-001, 2.261621e-002
10511, -1.254329e-001, 2.015671e-001, 2.326966e-002
10512, -1.159588e-001, 1.990747e-001, 2.580019e-002
10513, -1.161116e-001, 1.999084e-001, 2.532429e-002
10514, -1.162640e-001, 2.007337e-001, 2.483295e-002
10515, -1.164146e-001, 2.015483e-001, 2.432622e-002
10516, -1.158056e-001, 1.982332e-001, 2.625984e-002
10517, -1.156510e-001, 1.973836e-001, 2.670274e-002
10518, -1.151833e-001, 1.947884e-001, 2.793376e-002
10519, -1.153400e-001, 1.956611e-001, 2.753990e-002
10520, -1.150239e-001, 1.939080e-001, 2.830903e-002
10521, -1.148637e-001, 1.930208e-001, 2.866735e-002
10522, -1.147025e-001, 1.921269e-001, 2.900832e-002
10523, -1.145398e-001, 1.912265e-001, 2.933119e-002
10524, -1.143762e-001, 1.903203e-001, 2.963644e-002
10525, -1.142116e-001, 1.894083e-001, 2.992386e-002
10526, -1.140459e-001, 1.884911e-001, 3.019314e-002
10527, -1.138794e-001, 1.875689e-001, 3.044430e-002
10528, -1.137117e-001, 1.866417e-001, 3.067702e-002
10529, -1.135420e-001, 1.857098e-001, 3.089035e-002
10530, -1.133723e-001, 1.847763e-001, 3.108500e-002
10531, -1.132058e-001, 1.838436e-001, 3.126384e-002
10532, -1.130408e-001, 1.829117e-001, 3.142521e-002
10533, -1.128728e-001, 1.819751e-001, 3.156622e-002
10534, -1.127033e-001, 1.810323e-001, 3.168906e-002
10535, -1.125337e-001, 1.800833e-001, 3.179477e-002
10536, -1.109821e-001, 1.801259e-001, 2.724025e-002
10537, -1.109882e-001, 1.801873e-001, 2.822371e-002
10538, -1.111323e-001, 1.800223e-001, 2.627148e-002
10539, -1.111497e-001, 1.802032e-001, 2.919638e-002
10540, -1.114649e-001, 1.801897e-001, 3.012947e-002
10541, -1.119293e-001, 1.801482e-001, 3.100416e-002
10542, -1.118840e-001, 1.797161e-001, 2.448214e-002
10543, -1.114354e-001, 1.798824e-001, 2.534360e-002
10544, -1.124727e-001, 1.795378e-001, 2.370345e-002
10545, -1.131852e-001, 1.793553e-001, 2.303324e-002
10546, -1.139986e-001, 1.791717e-001, 2.249333e-002
10547, -1.148875e-001, 1.789875e-001, 2.209879e-002
10548, -1.158273e-001, 1.788057e-001, 2.185894e-002
10549, -1.167930e-001, 1.786297e-001, 2.177899e-002
10550, -1.177597e-001, 1.784632e-001, 2.186051e-002
10551, -1.187026e-001, 1.783103e-001, 2.210147e-002
10552, -1.195974e-001, 1.781762e-001, 2.249616e-002
10553, -1.204202e-001, 1.780680e-001, 2.303449e-002
10554, -1.211480e-001, 1.779968e-001, 2.370010e-002
10555, -1.217601e-001, 1.779767e-001, 2.446893e-002
10556, -1.222416e-001, 1.779939e-001, 2.532371e-002
10557, -1.225800e-001, 1.780416e-001, 2.624480e-002
10558, -1.227648e-001, 1.781123e-001, 2.721233e-002
10559, -1.227874e-001, 1.782003e-001, 2.820632e-002
10560, -1.226399e-001, 1.782983e-001, 2.920463e-002
10561, -1.223181e-001, 1.783893e-001, 3.017451e-002
10562, -1.218577e-001, 1.784472e-001, 3.103457e-002
10563, -1.212674e-001, 1.785645e-001, 3.181211e-002
10564, -1.165626e-001, 2.023514e-001, 2.380400e-002
10565, -1.154951e-001, 1.965260e-001, 2.712880e-002
10566, -1.252888e-001, 2.007757e-001, 2.381151e-002
10567, -1.251430e-001, 1.999735e-001, 2.433773e-002
10568, -1.249955e-001, 1.991607e-001, 2.484810e-002
10569, -1.248465e-001, 1.983381e-001, 2.534220e-002
10570, -1.246959e-001, 1.975062e-001, 2.581979e-002
10571, -1.245438e-001, 1.966655e-001, 2.628074e-002
10572, -1.243903e-001, 1.958161e-001, 2.672493e-002
10573, -1.242352e-001, 1.949585e-001, 2.715227e-002
10574, -1.240787e-001, 1.940929e-001, 2.756261e-002
10575, -1.239208e-001, 1.932196e-001, 2.795580e-002
10576, -1.237616e-001, 1.923389e-001, 2.833171e-002
10577, -1.236012e-001, 1.914513e-001, 2.869020e-002
10578, -1.234395e-001, 1.905569e-001, 2.903111e-002
10579, -1.232767e-001, 1.896562e-001, 2.935434e-002
10580, -1.231128e-001, 1.887496e-001, 2.965974e-002
10581, -1.229479e-001, 1.878372e-001, 2.994722e-002
10582, -1.227821e-001, 1.869196e-001, 3.021665e-002
10583, -1.226154e-001, 1.859970e-001, 3.046791e-002
10584, -1.224479e-001, 1.850700e-001, 3.070083e-002
10585, -1.222796e-001, 1.841382e-001, 3.091552e-002
10586, -1.221096e-001, 1.831993e-001, 3.111296e-002
10587, -1.219348e-001, 1.822527e-001, 3.129628e-002
10588, -1.217502e-001, 1.813102e-001, 3.147121e-002
10589, -1.215590e-001, 1.803962e-001, 3.163577e-002
10590, -1.214221e-001, 1.794979e-001, 3.172442e-002
10591, -1.158876e-001, 2.020333e-001, 2.314253e-002
10592, -1.153405e-001, 2.016408e-001, 2.240634e-002
10593, -1.149374e-001, 2.011859e-001, 2.161690e-002
10594, -1.146891e-001, 2.006827e-001, 2.079718e-002
10595, -1.146010e-001, 2.001457e-001, 1.997023e-002
10596, -1.146740e-001, 1.995900e-001, 1.915840e-002
10597, -1.149045e-001, 1.990302e-001, 1.838288e-002
10598, -1.152858e-001, 1.984809e-001, 1.766335e-002
10599, -1.158076e-001, 1.979558e-001, 1.701789e-002
10600, -1.164574e-001, 1.974679e-001, 1.646298e-002
10601, -1.172205e-001, 1.970287e-001, 1.601342e-002
10602, -1.180734e-001, 1.966533e-001, 1.568378e-002
10603, -1.189913e-001, 1.963526e-001, 1.548305e-002
10604, -1.199492e-001, 1.961343e-001, 1.541587e-002
10605, -1.209223e-001, 1.960037e-001, 1.548348e-002
10606, -1.218855e-001, 1.959641e-001, 1.568413e-002
10607, -1.228140e-001, 1.960169e-001, 1.601313e-002
10608, -1.236824e-001, 1.961611e-001, 1.646229e-002
10609, -1.244648e-001, 1.963921e-001, 1.701874e-002
10610, -1.251385e-001, 1.967024e-001, 1.766549e-002
10611, -1.256878e-001, 1.970843e-001, 1.838585e-002
10612, -1.260991e-001, 1.975282e-001, 1.916166e-002
10613, -1.263612e-001, 1.980232e-001, 1.997343e-002
10614, -1.264659e-001, 1.985565e-001, 2.080040e-002
10615, -1.264086e-001, 1.991139e-001, 2.162051e-002
10616, -1.261893e-001, 1.996803e-001, 2.241076e-002
10617, -1.258129e-001, 2.002394e-001, 2.314807e-002
10618, -1.154433e-001, 1.996263e-001, 2.463562e-002
10619, -1.155931e-001, 2.004391e-001, 2.415299e-002
10620, -1.151410e-001, 1.979759e-001, 2.555423e-002
10621, -1.152916e-001, 1.988045e-001, 2.510171e-002
10622, -1.149879e-001, 1.971391e-001, 2.598852e-002
10623, -1.157408e-001, 2.012412e-001, 2.365471e-002
10624, -1.219982e-001, 1.793895e-001, 3.097435e-002
10625, -1.140546e-001, 1.919664e-001, 2.825786e-002
10626, -1.142126e-001, 1.928458e-001, 2.792137e-002
10627, -1.143699e-001, 1.937187e-001, 2.756836e-002
10628, -1.115956e-001, 1.808288e-001, 2.525799e-002
10629, -1.112978e-001, 1.809780e-001, 2.618833e-002
10630, -1.145262e-001, 1.945849e-001, 2.719854e-002
10631, -1.146813e-001, 1.954438e-001, 2.681178e-002
10632, -1.138937e-001, 1.910802e-001, 2.857455e-002
10633, -1.137328e-001, 1.901884e-001, 2.887506e-002
10634, -1.135710e-001, 1.892911e-001, 2.915820e-002
10635, -1.134077e-001, 1.883883e-001, 2.942291e-002
10636, -1.132431e-001, 1.874799e-001, 2.966941e-002
10637, -1.130755e-001, 1.865654e-001, 2.989537e-002
10638, -1.129059e-001, 1.856484e-001, 3.010065e-002
10639, -1.127422e-001, 1.847331e-001, 3.029506e-002
10640, -1.125879e-001, 1.838257e-001, 3.048197e-002
10641, -1.124358e-001, 1.829269e-001, 3.065001e-002
10642, -1.122704e-001, 1.820171e-001, 3.078500e-002
10643, -1.120999e-001, 1.810907e-001, 3.090079e-002
10644, -1.116387e-001, 1.811250e-001, 3.003646e-002
10645, -1.120417e-001, 1.806570e-001, 2.439112e-002
10646, -1.111536e-001, 1.810888e-001, 2.715758e-002
10647, -1.111637e-001, 1.811451e-001, 2.814632e-002
10648, -1.113251e-001, 1.811364e-001, 2.911849e-002
10649, -1.133402e-001, 1.802838e-001, 2.293414e-002
10650, -1.126280e-001, 1.804746e-001, 2.360901e-002
10651, -1.141544e-001, 1.800906e-001, 2.239040e-002
10652, -1.150443e-001, 1.798975e-001, 2.199359e-002
10653, -1.159851e-001, 1.797105e-001, 2.175234e-002
10654, -1.169526e-001, 1.795333e-001, 2.167140e-002
10655, -1.179214e-001, 1.793699e-001, 2.175218e-002
10656, -1.188667e-001, 1.792244e-001, 2.199238e-002
10657, -1.197640e-001, 1.791020e-001, 2.238600e-002
10658, -1.205896e-001, 1.790090e-001, 2.292277e-002
10659, -1.213204e-001, 1.789546e-001, 2.358642e-002
10660, -1.219352e-001, 1.789488e-001, 2.435321e-002
10661, -1.224194e-001, 1.789804e-001, 2.520586e-002
10662, -1.227603e-001, 1.790412e-001, 2.612540e-002
10663, -1.229480e-001, 1.791258e-001, 2.709316e-002
10664, -1.229733e-001, 1.792326e-001, 2.809236e-002
10665, -1.228229e-001, 1.793578e-001, 2.911319e-002
10666, -1.224565e-001, 1.794822e-001, 3.017721e-002
10667, -1.148342e-001, 1.962948e-001, 2.640710e-002
10668, -1.256693e-001, 1.994503e-001, 2.366659e-002
10669, -1.255240e-001, 1.986505e-001, 2.416954e-002
10670, -1.253771e-001, 1.978409e-001, 2.465641e-002
10671, -1.252288e-001, 1.970220e-001, 2.512690e-002
10672, -1.250790e-001, 1.961945e-001, 2.558087e-002
10673, -1.249278e-001, 1.953585e-001, 2.601824e-002
10674, -1.247752e-001, 1.945144e-001, 2.643895e-002
10675, -1.246211e-001, 1.936624e-001, 2.684288e-002
10676, -1.244657e-001, 1.928029e-001, 2.722992e-002
10677, -1.243091e-001, 1.919362e-001, 2.759994e-002
10678, -1.241511e-001, 1.910626e-001, 2.795280e-002
10679, -1.239920e-001, 1.901824e-001, 2.828837e-002
10680, -1.238318e-001, 1.892959e-001, 2.860653e-002
10681, -1.236705e-001, 1.884036e-001, 2.890715e-002
10682, -1.235082e-001, 1.875056e-001, 2.919012e-002
10683, -1.233450e-001, 1.866025e-001, 2.945533e-002
10684, -1.231812e-001, 1.856954e-001, 2.970225e-002
10685, -1.230167e-001, 1.847841e-001, 2.993101e-002
10686, -1.228505e-001, 1.838647e-001, 3.014306e-002
10687, -1.226799e-001, 1.829310e-001, 3.034195e-002
10688, -1.224991e-001, 1.819838e-001, 3.053590e-002
10689, -1.222980e-001, 1.810471e-001, 3.074237e-002
10690, -1.220546e-001, 1.802002e-001, 3.100131e-002
10691, -1.151974e-001, 2.008623e-001, 2.290933e-002
10692, -1.147981e-001, 2.004224e-001, 2.211035e-002
10693, -1.145537e-001, 1.999352e-001, 2.128116e-002
10694, -1.144693e-001, 1.994146e-001, 2.044479e-002
10695, -1.145454e-001, 1.988750e-001, 1.962375e-002
10696, -1.147787e-001, 1.983309e-001, 1.883934e-002
10697, -1.151622e-001, 1.977959e-001, 1.811131e-002
10698, -1.156862e-001, 1.972836e-001, 1.745794e-002
10699, -1.163378e-001, 1.968065e-001, 1.689606e-002
10700, -1.171025e-001, 1.963756e-001, 1.644091e-002
10701, -1.179566e-001, 1.960064e-001, 1.610722e-002
10702, -1.188752e-001, 1.957095e-001, 1.590402e-002
10703, -1.198333e-001, 1.954924e-001, 1.583601e-002
10704, -1.208061e-001, 1.953605e-001, 1.590446e-002
10705, -1.217686e-001, 1.953171e-001, 1.610761e-002
10706, -1.226960e-001, 1.953636e-001, 1.644071e-002
10707, -1.235629e-001, 1.954993e-001, 1.689550e-002
10708, -1.243434e-001, 1.957197e-001, 1.745902e-002
10709, -1.250148e-001, 1.960175e-001, 1.811391e-002
10710, -1.255615e-001, 1.963854e-001, 1.884321e-002
10711, -1.259700e-001, 1.968142e-001, 1.962852e-002
10712, -1.262293e-001, 1.972933e-001, 2.045022e-002
10713, -1.263312e-001, 1.978105e-001, 2.128743e-002
10714, -1.262713e-001, 1.983523e-001, 2.211789e-002
10715, -1.260493e-001, 1.989037e-001, 2.291826e-002
10716, -1.146084e-001, 1.976525e-001, 2.476955e-002
10717, -1.147571e-001, 1.984672e-001, 2.432710e-002
10718, -1.141563e-001, 1.951646e-001, 2.600206e-002
10719, -1.143069e-001, 1.960004e-001, 2.560509e-002
10720, -1.227231e-001, 1.806809e-001, 2.989868e-002
10721, -1.144571e-001, 1.968294e-001, 2.519338e-002
10722, -1.150520e-001, 2.000730e-001, 2.339705e-002
10723, -1.135391e-001, 1.917492e-001, 2.741943e-002
10724, -1.136943e-001, 1.926126e-001, 2.708871e-002
10725, -1.130652e-001, 1.891223e-001, 2.830568e-002
10726, -1.132234e-001, 1.900031e-001, 2.802600e-002
10727, -1.117552e-001, 1.817862e-001, 2.515545e-002
10728, -1.114659e-001, 1.819480e-001, 2.608266e-002
10729, -1.133807e-001, 1.908785e-001, 2.772934e-002
10730, -1.138490e-001, 1.934698e-001, 2.674223e-002
10731, -1.140024e-001, 1.943202e-001, 2.637894e-002
10732, -1.129041e-001, 1.882346e-001, 2.856445e-002
10733, -1.127415e-001, 1.873409e-001, 2.880495e-002
10734, -1.125764e-001, 1.864414e-001, 2.902476e-002
10735, -1.124127e-001, 1.855387e-001, 2.923091e-002
10736, -1.122587e-001, 1.846374e-001, 2.944056e-002
10737, -1.121180e-001, 1.837564e-001, 2.964980e-002
10738, -1.119851e-001, 1.829095e-001, 2.983879e-002
10739, -1.118142e-001, 1.820332e-001, 2.994301e-002
10740, -1.121961e-001, 1.816094e-001, 2.428537e-002
10741, -1.151969e-001, 1.808270e-001, 2.186657e-002
10742, -1.143036e-001, 1.810296e-001, 2.226839e-002
10743, -1.127771e-001, 1.814250e-001, 2.350042e-002
10744, -1.149045e-001, 1.992738e-001, 2.386866e-002
10745, -1.113289e-001, 1.820744e-001, 2.705646e-002
10746, -1.113470e-001, 1.821306e-001, 2.807144e-002
10747, -1.115049e-001, 1.820420e-001, 2.906063e-002
10748, -1.161409e-001, 1.806349e-001, 2.162222e-002
10749, -1.171124e-001, 1.804564e-001, 2.153929e-002
10750, -1.134878e-001, 1.812317e-001, 2.281893e-002
10751, -1.180852e-001, 1.802966e-001, 2.161880e-002
10752, -1.190341e-001, 1.801592e-001, 2.185803e-002
10753, -1.199348e-001, 1.800491e-001, 2.225041e-002
10754, -1.207636e-001, 1.799720e-001, 2.278539e-002
10755, -1.214974e-001, 1.799342e-001, 2.344690e-002
10756, -1.221144e-001, 1.799397e-001, 2.421233e-002
10757, -1.225998e-001, 1.799781e-001, 2.506395e-002
10758, -1.229414e-001, 1.800438e-001, 2.598220e-002
10759, -1.231307e-001, 1.801384e-001, 2.694731e-002
10760, -1.231607e-001, 1.802670e-001, 2.793899e-002
10761, -1.230247e-001, 1.804386e-001, 2.893478e-002
10762, -1.259066e-001, 1.981185e-001, 2.341284e-002
10763, -1.257624e-001, 1.973235e-001, 2.389160e-002
10764, -1.256167e-001, 1.965193e-001, 2.435416e-002
10765, -1.254695e-001, 1.957065e-001, 2.480035e-002
10766, -1.253210e-001, 1.948854e-001, 2.523012e-002
10767, -1.251711e-001, 1.940563e-001, 2.564342e-002
10768, -1.250198e-001, 1.932196e-001, 2.604018e-002
10769, -1.248673e-001, 1.923755e-001, 2.642032e-002
10770, -1.247134e-001, 1.915242e-001, 2.678372e-002
10771, -1.245584e-001, 1.906662e-001, 2.713026e-002
10772, -1.244021e-001, 1.898018e-001, 2.745982e-002
10773, -1.242448e-001, 1.889312e-001, 2.777227e-002
10774, -1.240864e-001, 1.880548e-001, 2.806753e-002
10775, -1.239268e-001, 1.871732e-001, 2.834607e-002
10776, -1.237666e-001, 1.862884e-001, 2.860661e-002
10777, -1.236066e-001, 1.854011e-001, 2.884776e-002
10778, -1.234455e-001, 1.845071e-001, 2.907142e-002
10779, -1.232813e-001, 1.835976e-001, 2.928091e-002
10780, -1.231105e-001, 1.826632e-001, 2.948131e-002
10781, -1.229277e-001, 1.816962e-001, 2.968203e-002
10782, -1.146566e-001, 1.996482e-001, 2.258820e-002
10783, -1.144163e-001, 1.991770e-001, 2.174962e-002
10784, -1.143357e-001, 1.986730e-001, 2.090422e-002
10785, -1.144152e-001, 1.981498e-001, 2.007460e-002
10786, -1.146513e-001, 1.976213e-001, 1.928210e-002
10787, -1.150371e-001, 1.971008e-001, 1.854644e-002
10788, -1.155629e-001, 1.966010e-001, 1.788591e-002
10789, -1.162163e-001, 1.961346e-001, 1.731751e-002
10790, -1.169828e-001, 1.957128e-001, 1.685650e-002
10791, -1.178381e-001, 1.953504e-001, 1.651853e-002
10792, -1.187575e-001, 1.950576e-001, 1.631273e-002
10793, -1.197159e-001, 1.948419e-001, 1.624385e-002
10794, -1.206883e-001, 1.947087e-001, 1.631312e-002
10795, -1.216501e-001, 1.946613e-001, 1.651878e-002
10796, -1.225763e-001, 1.947013e-001, 1.685603e-002
10797, -1.234416e-001, 1.948279e-001, 1.731653e-002
10798, -1.242203e-001, 1.950374e-001, 1.788699e-002
10799, -1.248894e-001, 1.953228e-001, 1.854963e-002
10800, -1.254335e-001, 1.956768e-001, 1.928739e-002
10801, -1.258391e-001, 1.960905e-001, 2.008173e-002
10802, -1.260956e-001, 1.965537e-001, 2.091296e-002
10803, -1.261947e-001, 1.970547e-001, 2.176007e-002
10804, -1.261321e-001, 1.975806e-001, 2.260057e-002
10805, -1.137794e-001, 1.948318e-001, 2.513411e-002
10806, -1.139276e-001, 1.956517e-001, 2.474626e-002
10807, -1.116964e-001, 1.828797e-001, 2.907703e-002
10808, -1.136261e-001, 1.821860e-001, 2.268856e-002
10809, -1.129198e-001, 1.823786e-001, 2.337687e-002
10810, -1.136289e-001, 1.940037e-001, 2.550303e-002
10811, -1.127083e-001, 1.889048e-001, 2.739102e-002
10812, -1.128635e-001, 1.897686e-001, 2.711532e-002
10813, -1.123944e-001, 1.871591e-001, 2.789031e-002
10814, -1.125514e-001, 1.880343e-001, 2.764778e-002
10815, -1.172704e-001, 1.813916e-001, 2.138242e-002
10816, -1.162922e-001, 1.815718e-001, 2.146853e-002
10817, -1.130183e-001, 1.906276e-001, 2.682425e-002
10818, -1.131724e-001, 1.914810e-001, 2.651780e-002
10819, -1.134775e-001, 1.931691e-001, 2.585646e-002
10820, -1.120768e-001, 1.853797e-001, 2.833439e-002
10821, -1.122356e-001, 1.862733e-001, 2.811800e-002
10822, -1.119248e-001, 1.844809e-001, 2.856442e-002
10823, -1.117882e-001, 1.836123e-001, 2.880704e-002
10824, -1.123483e-001, 1.825614e-001, 2.416110e-002
10825, -1.119189e-001, 1.827438e-001, 2.502166e-002
10826, -1.182492e-001, 1.812356e-001, 2.146008e-002
10827, -1.153423e-001, 1.817690e-001, 2.171820e-002
10828, -1.144447e-001, 1.819768e-001, 2.212773e-002
10829, -1.143691e-001, 1.980730e-001, 2.349884e-002
10830, -1.145130e-001, 1.988639e-001, 2.304952e-002
10831, -1.116386e-001, 1.829233e-001, 2.593897e-002
10832, -1.115107e-001, 1.830918e-001, 2.691863e-002
10833, -1.115657e-001, 1.832726e-001, 2.800811e-002
10834, -1.192037e-001, 1.811058e-001, 2.169839e-002
10835, -1.201086e-001, 1.810071e-001, 2.208987e-002
10836, -1.142228e-001, 1.972727e-001, 2.392929e-002
10837, -1.209411e-001, 1.809439e-001, 2.262373e-002
10838, -1.216774e-001, 1.809191e-001, 2.328411e-002
10839, -1.222954e-001, 1.809284e-001, 2.405046e-002
10840, -1.227791e-001, 1.809625e-001, 2.490313e-002
10841, -1.231190e-001, 1.810246e-001, 2.582071e-002
10842, -1.233084e-001, 1.811230e-001, 2.678244e-002
10843, -1.233414e-001, 1.812639e-001, 2.776575e-002
10844, -1.232136e-001, 1.814524e-001, 2.874418e-002
10845, -1.140751e-001, 1.964650e-001, 2.434367e-002
10846, -1.133251e-001, 1.923279e-001, 2.619404e-002
10847, -1.259908e-001, 1.968013e-001, 2.307050e-002
10848, -1.258481e-001, 1.960128e-001, 2.352447e-002
10849, -1.257038e-001, 1.952159e-001, 2.396229e-002
10850, -1.255583e-001, 1.944108e-001, 2.438388e-002
10851, -1.254113e-001, 1.935980e-001, 2.478923e-002
10852, -1.252630e-001, 1.927776e-001, 2.517830e-002
10853, -1.251135e-001, 1.919499e-001, 2.555102e-002
10854, -1.249627e-001, 1.911153e-001, 2.590730e-002
10855, -1.248107e-001, 1.902741e-001, 2.624704e-002
10856, -1.246575e-001, 1.894265e-001, 2.657012e-002
10857, -1.245033e-001, 1.885730e-001, 2.687652e-002
10858, -1.243476e-001, 1.877144e-001, 2.716832e-002
10859, -1.241908e-001, 1.868538e-001, 2.744493e-002
10860, -1.240344e-001, 1.859932e-001, 2.770164e-002
10861, -1.238789e-001, 1.851288e-001, 2.793461e-002
10862, -1.237216e-001, 1.842514e-001, 2.815045e-002
10863, -1.235598e-001, 1.833509e-001, 2.835451e-002
10864, -1.233911e-001, 1.824188e-001, 2.855112e-002
10865, -1.142770e-001, 1.984090e-001, 2.220174e-002
10866, -1.142006e-001, 1.979215e-001, 2.134749e-002
10867, -1.142838e-001, 1.974149e-001, 2.050974e-002
10868, -1.145228e-001, 1.969024e-001, 1.970988e-002
10869, -1.149107e-001, 1.963966e-001, 1.896742e-002
10870, -1.154383e-001, 1.959099e-001, 1.830035e-002
10871, -1.160935e-001, 1.954543e-001, 1.772571e-002
10872, -1.168617e-001, 1.950418e-001, 1.725913e-002
10873, -1.177182e-001, 1.946863e-001, 1.691701e-002
10874, -1.186383e-001, 1.943977e-001, 1.670868e-002
10875, -1.195969e-001, 1.941836e-001, 1.663893e-002
10876, -1.205692e-001, 1.940490e-001, 1.670900e-002
10877, -1.215302e-001, 1.939975e-001, 1.691710e-002
10878, -1.224552e-001, 1.940308e-001, 1.725840e-002
10879, -1.233190e-001, 1.941483e-001, 1.772444e-002
10880, -1.240957e-001, 1.943467e-001, 1.830166e-002
10881, -1.247624e-001, 1.946195e-001, 1.897174e-002
10882, -1.253038e-001, 1.949594e-001, 1.971757e-002
10883, -1.257066e-001, 1.953578e-001, 2.052055e-002
10884, -1.259602e-001, 1.958049e-001, 2.136095e-002
10885, -1.260566e-001, 1.962896e-001, 2.221767e-002
10886, -1.193748e-001, 1.820566e-001, 2.151405e-002
10887, -1.184114e-001, 1.821802e-001, 2.127608e-002
10888, -1.125001e-001, 1.835005e-001, 2.401426e-002
10889, -1.120836e-001, 1.836806e-001, 2.485834e-002
10890, -1.137586e-001, 1.831390e-001, 2.254019e-002
10891, -1.130604e-001, 1.833242e-001, 2.323328e-002
10892, -1.118114e-001, 1.838683e-001, 2.575546e-002
10893, -1.116883e-001, 1.840577e-001, 2.669933e-002
10894, -1.134139e-001, 1.936444e-001, 2.459492e-002
10895, -1.135606e-001, 1.944554e-001, 2.423382e-002
10896, -1.125108e-001, 1.886443e-001, 2.644574e-002
10897, -1.126632e-001, 1.894913e-001, 2.617091e-002
10898, -1.131169e-001, 1.920025e-001, 2.527028e-002
10899, -1.132655e-001, 1.928255e-001, 2.493747e-002
10900, -1.123587e-001, 1.877976e-001, 2.670868e-002
10901, -1.137062e-001, 1.952598e-001, 2.385728e-002
10902, -1.138507e-001, 1.960576e-001, 2.346588e-002
10903, -1.139941e-001, 1.968488e-001, 2.305970e-002
10904, -1.117284e-001, 1.842589e-001, 2.767126e-002
10905, -1.118902e-001, 1.851812e-001, 2.742082e-002
10906, -1.211223e-001, 1.819140e-001, 2.244074e-002
10907, -1.202848e-001, 1.819669e-001, 2.190559e-002
10908, -1.145794e-001, 1.829261e-001, 2.196748e-002
10909, -1.174232e-001, 1.823337e-001, 2.120086e-002
10910, -1.154818e-001, 1.827135e-001, 2.154840e-002
10911, -1.128153e-001, 1.903342e-001, 2.588396e-002
10912, -1.129664e-001, 1.911710e-001, 2.558299e-002
10913, -1.141361e-001, 1.976322e-001, 2.263740e-002
10914, -1.164374e-001, 1.825135e-001, 2.129189e-002
10915, -1.120493e-001, 1.860723e-001, 2.719067e-002
10916, -1.122052e-001, 1.869420e-001, 2.695701e-002
10917, -1.224779e-001, 1.818990e-001, 2.387468e-002
10918, -1.218601e-001, 1.818939e-001, 2.310303e-002
10919, -1.229573e-001, 1.819201e-001, 2.473174e-002
10920, -1.232924e-001, 1.819730e-001, 2.564887e-002
10921, -1.234799e-001, 1.820709e-001, 2.660647e-002
10922, -1.235141e-001, 1.822182e-001, 2.758234e-002
10923, -1.259170e-001, 1.955176e-001, 2.266260e-002
10924, -1.257759e-001, 1.947371e-001, 2.309164e-002
10925, -1.256335e-001, 1.939487e-001, 2.350471e-002
10926, -1.254896e-001, 1.931527e-001, 2.390179e-002
10927, -1.253444e-001, 1.923493e-001, 2.428286e-002
10928, -1.251980e-001, 1.915387e-001, 2.464788e-002
10929, -1.250504e-001, 1.907214e-001, 2.499678e-002
10930, -1.249015e-001, 1.898976e-001, 2.532947e-002
10931, -1.247516e-001, 1.890676e-001, 2.564595e-002
10932, -1.246004e-001, 1.882327e-001, 2.594951e-002
10933, -1.244484e-001, 1.873959e-001, 2.624338e-002
10934, -1.242963e-001, 1.865618e-001, 2.652480e-002
10935, -1.241453e-001, 1.857317e-001, 2.678247e-002
10936, -1.239949e-001, 1.848942e-001, 2.699922e-002
10937, -1.238407e-001, 1.840334e-001, 2.720004e-002
10938, -1.236806e-001, 1.831413e-001, 2.739323e-002
10939, -1.140640e-001, 1.971611e-001, 2.177414e-002
10940, -1.141513e-001, 1.966711e-001, 2.092850e-002
10941, -1.143934e-001, 1.961749e-001, 2.012185e-002
10942, -1.147836e-001, 1.956844e-001, 1.937329e-002
10943, -1.153128e-001, 1.952112e-001, 1.870030e-002
10944, -1.159696e-001, 1.947669e-001, 1.811982e-002
10945, -1.167393e-001, 1.943636e-001, 1.764814e-002
10946, -1.175970e-001, 1.940149e-001, 1.730215e-002
10947, -1.185176e-001, 1.937305e-001, 1.709153e-002
10948, -1.194764e-001, 1.935178e-001, 1.702095e-002
10949, -1.204485e-001, 1.933819e-001, 1.709175e-002
10950, -1.214089e-001, 1.933264e-001, 1.730217e-002
10951, -1.223328e-001, 1.933529e-001, 1.764734e-002
10952, -1.231950e-001, 1.934613e-001, 1.811865e-002
10953, -1.239697e-001, 1.936486e-001, 1.870235e-002
10954, -1.246339e-001, 1.939086e-001, 1.937960e-002
10955, -1.251725e-001, 1.942341e-001, 2.013314e-002
10956, -1.255724e-001, 1.946168e-001, 2.094440e-002
10957, -1.258232e-001, 1.950476e-001, 2.179367e-002
10958, -1.126467e-001, 1.844154e-001, 2.385227e-002
10959, -1.122416e-001, 1.845846e-001, 2.468228e-002
10960, -1.135046e-001, 1.940486e-001, 2.333109e-002
10961, -1.136463e-001, 1.948366e-001, 2.296401e-002
10962, -1.138849e-001, 1.840848e-001, 2.237494e-002
10963, -1.131943e-001, 1.842557e-001, 2.307576e-002
10964, -1.204639e-001, 1.829235e-001, 2.169897e-002
10965, -1.195434e-001, 1.830063e-001, 2.130472e-002
10966, -1.124742e-001, 1.883428e-001, 2.549939e-002
10967, -1.126270e-001, 1.891796e-001, 2.521978e-002
10968, -1.156146e-001, 1.836606e-001, 2.135726e-002
10969, -1.147064e-001, 1.838750e-001, 2.178865e-002
10970, -1.123239e-001, 1.875357e-001, 2.578316e-002
10971, -1.137869e-001, 1.956182e-001, 2.258208e-002
10972, -1.165781e-001, 1.834568e-001, 2.109205e-002
10973, -1.213061e-001, 1.828758e-001, 2.223770e-002
10974, -1.185701e-001, 1.831253e-001, 2.106715e-002
10975, -1.175713e-001, 1.832765e-001, 2.099523e-002
10976, -1.220483e-001, 1.828576e-001, 2.290777e-002
10977, -1.236465e-001, 1.829867e-001, 2.642619e-002
10978, -1.234642e-001, 1.828917e-001, 2.547618e-002
10979, -1.226639e-001, 1.828478e-001, 2.369104e-002
10980, -1.139261e-001, 1.963925e-001, 2.218433e-002
10981, -1.129254e-001, 1.908312e-001, 2.464488e-002
10982, -1.130721e-001, 1.916444e-001, 2.433738e-002
10983, -1.133616e-001, 1.932527e-001, 2.368001e-002
10984, -1.120172e-001, 1.858573e-001, 2.626128e-002
10985, -1.121720e-001, 1.867081e-001, 2.603477e-002
10986, -1.231391e-001, 1.828540e-001, 2.456086e-002
10987, -1.127773e-001, 1.900092e-001, 2.493572e-002
10988, -1.132175e-001, 1.924507e-001, 2.401426e-002
10989, -1.119766e-001, 1.847741e-001, 2.556049e-002
10990, -1.118560e-001, 1.849735e-001, 2.648201e-002
10991, -1.256854e-001, 1.942838e-001, 2.221374e-002
10992, -1.255461e-001, 1.935122e-001, 2.261814e-002
10993, -1.254054e-001, 1.927331e-001, 2.300684e-002
10994, -1.252634e-001, 1.919468e-001, 2.337985e-002
10995, -1.251201e-001, 1.911536e-001, 2.373712e-002
10996, -1.249756e-001, 1.903537e-001, 2.407860e-002
10997, -1.248300e-001, 1.895475e-001, 2.440430e-002
10998, -1.246836e-001, 1.887358e-001, 2.471663e-002
10999, -1.245375e-001, 1.879208e-001, 2.502167e-002
11000, -1.243928e-001, 1.871064e-001, 2.532477e-002
11001, -1.242510e-001, 1.863013e-001, 2.562505e-002
11002, -1.241121e-001, 1.855138e-001, 2.590359e-002
11003, -1.239645e-001, 1.847152e-001, 2.607624e-002
11004, -1.238086e-001, 1.838705e-001, 2.624943e-002
11005, -1.140177e-001, 1.959191e-001, 2.133088e-002
11006, -1.142634e-001, 1.954391e-001, 2.051759e-002
11007, -1.146560e-001, 1.949643e-001, 1.976337e-002
11008, -1.151868e-001, 1.945051e-001, 1.908520e-002
11009, -1.158449e-001, 1.940726e-001, 1.849958e-002
11010, -1.166159e-001, 1.936787e-001, 1.802324e-002
11011, -1.174743e-001, 1.933368e-001, 1.767388e-002
11012, -1.183940e-001, 1.930559e-001, 1.746171e-002
11013, -1.193527e-001, 1.928438e-001, 1.739044e-002
11014, -1.203251e-001, 1.927064e-001, 1.746180e-002
11015, -1.212856e-001, 1.926471e-001, 1.767425e-002
11016, -1.222089e-001, 1.926675e-001, 1.802288e-002
11017, -1.230696e-001, 1.927673e-001, 1.849902e-002
11018, -1.238424e-001, 1.929435e-001, 1.908881e-002
11019, -1.245040e-001, 1.931904e-001, 1.977284e-002
11020, -1.250396e-001, 1.935011e-001, 2.053372e-002
11021, -1.254367e-001, 1.938680e-001, 2.135293e-002
11022, -1.136092e-001, 1.936217e-001, 2.244784e-002
11023, -1.137466e-001, 1.943940e-001, 2.209046e-002
11024, -1.222374e-001, 1.838012e-001, 2.269797e-002
11025, -1.214898e-001, 1.838218e-001, 2.201582e-002
11026, -1.138830e-001, 1.951594e-001, 2.171715e-002
11027, -1.206398e-001, 1.838702e-001, 2.146912e-002
11028, -1.124297e-001, 1.872675e-001, 2.492519e-002
11029, -1.125939e-001, 1.879706e-001, 2.457259e-002
11030, -1.148252e-001, 1.848286e-001, 2.159104e-002
11031, -1.140004e-001, 1.850279e-001, 2.219707e-002
11032, -1.122815e-001, 1.864763e-001, 2.516209e-002
11033, -1.197098e-001, 1.839526e-001, 2.107081e-002
11034, -1.187263e-001, 1.840701e-001, 2.083329e-002
11035, -1.177178e-001, 1.842204e-001, 2.076493e-002
11036, -1.133313e-001, 1.920572e-001, 2.311478e-002
11037, -1.134714e-001, 1.928412e-001, 2.278628e-002
11038, -1.131907e-001, 1.912672e-001, 2.342550e-002
11039, -1.233359e-001, 1.837835e-001, 2.440627e-002
11040, -1.228562e-001, 1.837828e-001, 2.350137e-002
11041, -1.236361e-001, 1.837794e-001, 2.531394e-002
11042, -1.129046e-001, 1.896687e-001, 2.400642e-002
11043, -1.130491e-001, 1.904721e-001, 2.372073e-002
11044, -1.121328e-001, 1.856438e-001, 2.536429e-002
11045, -1.127565e-001, 1.888485e-001, 2.428218e-002
11046, -1.123856e-001, 1.854529e-001, 2.451307e-002
11047, -1.127772e-001, 1.853068e-001, 2.369555e-002
11048, -1.253005e-001, 1.931129e-001, 2.174871e-002
11049, -1.251630e-001, 1.923504e-001, 2.212915e-002
11050, -1.250241e-001, 1.915810e-001, 2.249422e-002
11051, -1.248839e-001, 1.908047e-001, 2.284388e-002
11052, -1.247426e-001, 1.900220e-001, 2.317824e-002
11053, -1.246005e-001, 1.892331e-001, 2.349823e-002
11054, -1.244588e-001, 1.884391e-001, 2.380765e-002
11055, -1.243199e-001, 1.876412e-001, 2.411504e-002
11056, -1.241869e-001, 1.868416e-001, 2.443031e-002
11057, -1.240651e-001, 1.860540e-001, 2.476494e-002
11058, -1.239722e-001, 1.853390e-001, 2.514347e-002
11059, -1.238057e-001, 1.846189e-001, 2.517401e-002
11060, -1.157410e-001, 1.846082e-001, 2.114478e-002
11061, -1.133134e-001, 1.851777e-001, 2.291527e-002
11062, -1.167140e-001, 1.844012e-001, 2.086881e-002
11063, -1.141328e-001, 1.946955e-001, 2.089678e-002
11064, -1.145286e-001, 1.942360e-001, 2.013685e-002
11065, -1.150610e-001, 1.937912e-001, 1.945424e-002
11066, -1.157199e-001, 1.933712e-001, 1.886460e-002
11067, -1.164915e-001, 1.929872e-001, 1.838442e-002
11068, -1.173473e-001, 1.926519e-001, 1.803345e-002
11069, -1.182617e-001, 1.923708e-001, 1.782214e-002
11070, -1.192209e-001, 1.921563e-001, 1.775039e-002
11071, -1.201959e-001, 1.920167e-001, 1.782177e-002
11072, -1.211584e-001, 1.919548e-001, 1.803541e-002
11073, -1.220825e-001, 1.919715e-001, 1.838635e-002
11074, -1.229426e-001, 1.920650e-001, 1.886597e-002
11075, -1.237135e-001, 1.922311e-001, 1.946103e-002
11076, -1.243724e-001, 1.924649e-001, 2.015131e-002
11077, -1.249052e-001, 1.927608e-001, 2.091912e-002
11078, -1.224182e-001, 1.847158e-001, 2.246924e-002
11079, -1.216729e-001, 1.847571e-001, 2.177353e-002
11080, -1.149346e-001, 1.857946e-001, 2.137402e-002
11081, -1.140987e-001, 1.859811e-001, 2.201226e-002
11082, -1.130565e-001, 1.885568e-001, 2.337107e-002
11083, -1.131934e-001, 1.893319e-001, 2.311653e-002
11084, -1.208181e-001, 1.848165e-001, 2.121565e-002
11085, -1.134053e-001, 1.861022e-001, 2.276945e-002
11086, -1.128780e-001, 1.861724e-001, 2.357154e-002
11087, -1.188859e-001, 1.850193e-001, 2.057331e-002
11088, -1.178676e-001, 1.851684e-001, 2.050834e-002
11089, -1.158661e-001, 1.855645e-001, 2.090691e-002
11090, -1.138690e-001, 1.931871e-001, 2.160829e-002
11091, -1.140018e-001, 1.939441e-001, 2.125934e-002
11092, -1.126005e-001, 1.869949e-001, 2.427555e-002
11093, -1.129042e-001, 1.878456e-001, 2.365074e-002
11094, -1.125076e-001, 1.862706e-001, 2.437191e-002
11095, -1.198782e-001, 1.849020e-001, 2.081127e-002
11096, -1.136016e-001, 1.916546e-001, 2.225725e-002
11097, -1.137367e-001, 1.924224e-001, 2.193815e-002
11098, -1.134669e-001, 1.908840e-001, 2.255777e-002
11099, -1.235732e-001, 1.847383e-001, 2.431606e-002
11100, -1.230467e-001, 1.847092e-001, 2.329138e-002
11101, -1.133315e-001, 1.901113e-001, 2.284271e-002
11102, -1.168533e-001, 1.853509e-001, 2.061889e-002
11103, -1.247706e-001, 1.920143e-001, 2.129158e-002
11104, -1.246347e-001, 1.912608e-001, 2.164903e-002
11105, -1.244975e-001, 1.905007e-001, 2.199161e-002
11106, -1.243596e-001, 1.897339e-001, 2.232018e-002
11107, -1.242216e-001, 1.889611e-001, 2.263587e-002
11108, -1.240847e-001, 1.881826e-001, 2.294095e-002
11109, -1.239533e-001, 1.873979e-001, 2.324613e-002
11110, -1.238283e-001, 1.865974e-001, 2.356082e-002
11111, -1.237024e-001, 1.857455e-001, 2.389458e-002
11112, -1.144016e-001, 1.934995e-001, 2.049316e-002
11113, -1.149364e-001, 1.930693e-001, 1.980657e-002
11114, -1.155952e-001, 1.926627e-001, 1.921449e-002
11115, -1.163635e-001, 1.922900e-001, 1.873304e-002
11116, -1.172084e-001, 1.919585e-001, 1.838508e-002
11117, -1.181077e-001, 1.916656e-001, 1.818015e-002
11118, -1.190724e-001, 1.914425e-001, 1.810702e-002
11119, -1.200556e-001, 1.913001e-001, 1.817702e-002
11120, -1.210246e-001, 1.912387e-001, 1.839033e-002
11121, -1.219525e-001, 1.912573e-001, 1.874129e-002
11122, -1.228134e-001, 1.913514e-001, 1.922116e-002
11123, -1.235829e-001, 1.915107e-001, 1.981936e-002
11124, -1.242393e-001, 1.917323e-001, 2.051499e-002
11125, -1.150298e-001, 1.867981e-001, 2.113592e-002
11126, -1.141675e-001, 1.869486e-001, 2.183320e-002
11127, -1.180278e-001, 1.861234e-001, 2.022314e-002
11128, -1.170035e-001, 1.863065e-001, 2.033916e-002
11129, -1.134522e-001, 1.870529e-001, 2.266702e-002
11130, -1.134478e-001, 1.881259e-001, 2.262928e-002
11131, -1.136219e-001, 1.889843e-001, 2.231061e-002
11132, -1.129292e-001, 1.870115e-001, 2.352665e-002
11133, -1.159982e-001, 1.865344e-001, 2.063775e-002
11134, -1.142746e-001, 1.927561e-001, 2.083302e-002
11135, -1.200593e-001, 1.858659e-001, 2.052433e-002
11136, -1.190559e-001, 1.859775e-001, 2.028550e-002
11137, -1.140177e-001, 1.912567e-001, 2.146719e-002
11138, -1.141472e-001, 1.920077e-001, 2.115680e-002
11139, -1.138889e-001, 1.905082e-001, 2.175915e-002
11140, -1.231996e-001, 1.856143e-001, 2.301198e-002
11141, -1.137587e-001, 1.897597e-001, 2.203698e-002
11142, -1.218766e-001, 1.857041e-001, 2.151737e-002
11143, -1.210154e-001, 1.857804e-001, 2.093933e-002
11144, -1.225983e-001, 1.855828e-001, 2.224105e-002
11145, -1.241061e-001, 1.909934e-001, 2.086556e-002
11146, -1.239722e-001, 1.902473e-001, 2.120280e-002
11147, -1.238396e-001, 1.894937e-001, 2.152960e-002
11148, -1.237090e-001, 1.887348e-001, 2.184581e-002
11149, -1.235758e-001, 1.879711e-001, 2.214400e-002
11150, -1.234552e-001, 1.872058e-001, 2.244544e-002
11151, -1.233481e-001, 1.864399e-001, 2.275179e-002
11152, -1.148124e-001, 1.923405e-001, 2.014241e-002
11153, -1.154691e-001, 1.919485e-001, 1.955020e-002
11154, -1.162249e-001, 1.915896e-001, 1.907302e-002
11155, -1.170444e-001, 1.912569e-001, 1.873431e-002
11156, -1.179050e-001, 1.909246e-001, 1.854860e-002
11157, -1.188970e-001, 1.906831e-001, 1.846830e-002
11158, -1.199006e-001, 1.905388e-001, 1.853415e-002
11159, -1.208834e-001, 1.904826e-001, 1.874569e-002
11160, -1.218205e-001, 1.905126e-001, 1.909439e-002
11161, -1.226841e-001, 1.906210e-001, 1.956878e-002
11162, -1.234511e-001, 1.907812e-001, 2.016495e-002
11163, -1.182013e-001, 1.870798e-001, 1.990960e-002
11164, -1.171715e-001, 1.872579e-001, 2.002941e-002
11165, -1.161570e-001, 1.875058e-001, 2.032923e-002
11166, -1.151007e-001, 1.879125e-001, 2.086765e-002
11167, -1.142000e-001, 1.887389e-001, 2.155814e-002
11168, -1.144339e-001, 1.901565e-001, 2.105624e-002
11169, -1.145599e-001, 1.908778e-001, 2.076959e-002
11170, -1.202597e-001, 1.868463e-001, 2.020923e-002
11171, -1.192376e-001, 1.869411e-001, 1.996982e-002
11172, -1.228286e-001, 1.863635e-001, 2.209541e-002
11173, -1.221665e-001, 1.867615e-001, 2.125134e-002
11174, -1.212548e-001, 1.867857e-001, 2.064005e-002
11175, -1.143080e-001, 1.894548e-001, 2.132386e-002
11176, -1.146872e-001, 1.916086e-001, 2.046320e-002
11177, -1.141932e-001, 1.879100e-001, 2.168153e-002
11178, -1.233223e-001, 1.900433e-001, 2.050162e-002
11179, -1.232034e-001, 1.892958e-001, 2.083759e-002
11180, -1.230992e-001, 1.885501e-001, 2.117129e-002
11181, -1.229575e-001, 1.877987e-001, 2.145023e-002
11182, -1.228509e-001, 1.870388e-001, 2.175558e-002
11183, -1.153375e-001, 1.912329e-001, 1.987451e-002
11184, -1.160667e-001, 1.908934e-001, 1.940798e-002
11185, -1.168433e-001, 1.905685e-001, 1.907920e-002
11186, -1.175822e-001, 1.901199e-001, 1.895795e-002
11187, -1.186936e-001, 1.898552e-001, 1.884079e-002
11188, -1.197347e-001, 1.897155e-001, 1.889830e-002
11189, -1.207399e-001, 1.896686e-001, 1.910905e-002
11190, -1.216951e-001, 1.897205e-001, 1.945714e-002
11191, -1.225637e-001, 1.898700e-001, 1.991737e-002
11192, -1.163842e-001, 1.883927e-001, 1.998450e-002
11193, -1.155264e-001, 1.887342e-001, 2.037903e-002
11194, -1.183771e-001, 1.880229e-001, 1.957282e-002
11195, -1.173505e-001, 1.881832e-001, 1.969773e-002
11196, -1.194176e-001, 1.878974e-001, 1.962866e-002
11197, -1.147224e-001, 1.886254e-001, 2.103951e-002
11198, -1.222630e-001, 1.876718e-001, 2.087479e-002
11199, -1.215358e-001, 1.878122e-001, 2.032423e-002
11200, -1.151981e-001, 1.905228e-001, 2.018772e-002
11201, -1.150570e-001, 1.898256e-001, 2.048334e-002
11202, -1.149047e-001, 1.891715e-001, 2.076471e-002
11203, -1.224775e-001, 1.891108e-001, 2.027849e-002
11204, -1.224839e-001, 1.883932e-001, 2.067456e-002
11205, -1.204638e-001, 1.878238e-001, 1.986760e-002
11206, -1.158900e-001, 1.902086e-001, 1.973571e-002
11207, -1.165673e-001, 1.899696e-001, 1.941593e-002
11208, -1.174927e-001, 1.891024e-001, 1.935168e-002
11209, -1.185329e-001, 1.889428e-001, 1.921898e-002
11210, -1.195760e-001, 1.888236e-001, 1.926952e-002
11211, -1.206034e-001, 1.887805e-001, 1.948658e-002
11212, -1.215963e-001, 1.888521e-001, 1.985117e-002
11213, -1.157388e-001, 1.894852e-001, 2.004174e-002
11214, -1.165297e-001, 1.892154e-001, 1.967321e-002
11215, -1.239928e-001, 2.241708e-001, 7.568553e-003
11216, -1.230093e-001, 2.242037e-001, 7.360903e-003
11217, -1.220684e-001, 2.241276e-001, 7.033354e-003
11218, -1.212023e-001, 2.239371e-001, 6.613182e-003
11219, -1.204430e-001, 2.236278e-001, 6.148791e-003
11220, -1.198039e-001, 2.232047e-001, 5.687539e-003
11221, -1.192802e-001, 2.226746e-001, 5.264756e-003
11222, -1.188635e-001, 2.220373e-001, 4.927357e-003
11223, -1.185419e-001, 2.212978e-001, 4.731235e-003
11224, -1.182932e-001, 2.204887e-001, 4.661952e-003
11225, -1.180978e-001, 2.196311e-001, 4.688395e-003
11226, -1.179444e-001, 2.187385e-001, 4.783497e-003
11227, -1.178269e-001, 2.178194e-001, 4.927507e-003
11228, -1.177427e-001, 2.168798e-001, 5.106342e-003
11229, -1.176915e-001, 2.159247e-001, 5.309637e-003
11230, -1.176744e-001, 2.149584e-001, 5.529712e-003
11231, -1.176939e-001, 2.139839e-001, 5.760612e-003
11232, -1.177537e-001, 2.130029e-001, 5.997866e-003
11233, -1.178598e-001, 2.120174e-001, 6.237233e-003
11234, -1.180204e-001, 2.110297e-001, 6.474911e-003
11235, -1.182480e-001, 2.100436e-001, 6.706491e-003
11236, -1.185595e-001, 2.090673e-001, 6.927532e-003
11237, -1.189674e-001, 2.081249e-001, 7.137053e-003
11238, -1.194495e-001, 2.072908e-001, 7.326888e-003
11239, -1.199411e-001, 2.067189e-001, 7.427124e-003
11240, -1.203493e-001, 2.057209e-001, 7.980966e-003
11241, -1.209746e-001, 2.051983e-001, 8.169934e-003
11242, -1.220965e-001, 2.051161e-001, 8.060242e-003
11243, -1.228911e-001, 2.054913e-001, 7.769795e-003
11244, -1.237371e-001, 2.057844e-001, 7.688529e-003
11245, -1.245987e-001, 2.059373e-001, 7.908435e-003
11246, -1.250309e-001, 2.068611e-001, 7.274827e-003
11247, -1.257876e-001, 2.076975e-001, 7.006199e-003
11248, -1.264172e-001, 2.085311e-001, 6.757904e-003
11249, -1.269731e-001, 2.093866e-001, 6.515131e-003
11250, -1.274691e-001, 2.102635e-001, 6.272102e-003
11251, -1.279141e-001, 2.111572e-001, 6.029431e-003
11252, -1.283147e-001, 2.120634e-001, 5.789681e-003
11253, -1.286754e-001, 2.129790e-001, 5.556936e-003
11254, -1.289994e-001, 2.139018e-001, 5.335989e-003
11255, -1.292878e-001, 2.148301e-001, 5.132327e-003
11256, -1.295399e-001, 2.157606e-001, 4.955881e-003
11257, -1.297522e-001, 2.166881e-001, 4.818570e-003
11258, -1.299169e-001, 2.176004e-001, 4.736720e-003
11259, -1.300249e-001, 2.184903e-001, 4.723013e-003
11260, -1.300620e-001, 2.193527e-001, 4.795901e-003
11261, -1.300058e-001, 2.201747e-001, 4.978925e-003
11262, -1.298291e-001, 2.209284e-001, 5.285072e-003
11263, -1.295191e-001, 2.216026e-001, 5.679436e-003
11264, -1.290719e-001, 2.222023e-001, 6.116539e-003
11265, -1.284903e-001, 2.227389e-001, 6.547626e-003
11266, -1.277899e-001, 2.232119e-001, 6.926300e-003
11267, -1.269973e-001, 2.235891e-001, 7.236737e-003
11268, -1.261565e-001, 2.237276e-001, 7.562758e-003
11269, -1.211367e-001, 2.082715e-001, 2.112670e-002
11270, -1.212730e-001, 2.090278e-001, 2.048173e-002
11271, -1.214092e-001, 2.097842e-001, 1.983673e-002
11272, -1.215454e-001, 2.105407e-001, 1.919171e-002
11273, -1.216817e-001, 2.112971e-001, 1.854667e-002
11274, -1.218179e-001, 2.120536e-001, 1.790161e-002
11275, -1.219543e-001, 2.128101e-001, 1.725656e-002
11276, -1.220908e-001, 2.135665e-001, 1.661154e-002
11277, -1.222273e-001, 2.143229e-001, 1.596655e-002
11278, -1.223639e-001, 2.150794e-001, 1.532157e-002
11279, -1.225005e-001, 2.158358e-001, 1.467658e-002
11280, -1.226371e-001, 2.165922e-001, 1.403160e-002
11281, -1.227737e-001, 2.173485e-001, 1.338673e-002
11282, -1.229099e-001, 2.181046e-001, 1.274194e-002
11283, -1.230463e-001, 2.188611e-001, 1.209685e-002
11284, -1.231827e-001, 2.196180e-001, 1.145148e-002
11285, -1.233178e-001, 2.203755e-001, 1.080548e-002
11286, -1.234509e-001, 2.211342e-001, 1.015830e-002
11287, -1.235834e-001, 2.218941e-001, 9.509997e-003
11288, -1.237175e-001, 2.226544e-001, 8.861507e-003
11289, -1.238540e-001, 2.234137e-001, 8.213940e-003
11290, -1.201633e-001, 2.082882e-001, 2.094035e-002
11291, -1.192246e-001, 2.081975e-001, 2.063544e-002
11292, -1.183463e-001, 2.080017e-001, 2.022040e-002
11293, -1.175523e-001, 2.077065e-001, 1.970657e-002
11294, -1.168641e-001, 2.073198e-001, 1.910784e-002
11295, -1.163005e-001, 2.068522e-001, 1.844046e-002
11296, -1.158768e-001, 2.063165e-001, 1.772260e-002
11297, -1.156047e-001, 2.057277e-001, 1.697369e-002
11298, -1.154916e-001, 2.051015e-001, 1.621424e-002
11299, -1.155404e-001, 2.044545e-001, 1.546519e-002
11300, -1.157499e-001, 2.038038e-001, 1.474753e-002
11301, -1.161139e-001, 2.031661e-001, 1.408234e-002
11302, -1.166213e-001, 2.025585e-001, 1.348932e-002
11303, -1.172580e-001, 2.020034e-001, 1.297992e-002
11304, -1.180067e-001, 2.015307e-001, 1.255560e-002
11305, -1.188552e-001, 2.011173e-001, 1.224673e-002
11306, -1.197702e-001, 2.008091e-001, 1.204534e-002
11307, -1.207440e-001, 2.006033e-001, 1.195920e-002
11308, -1.217497e-001, 2.004721e-001, 1.202739e-002
11309, -1.227250e-001, 2.004377e-001, 1.223362e-002
11310, -1.236593e-001, 2.005185e-001, 1.255049e-002
11311, -1.245308e-001, 2.007096e-001, 1.296938e-002
11312, -1.253215e-001, 2.010040e-001, 1.348424e-002
11313, -1.260099e-001, 2.013934e-001, 1.408462e-002
11314, -1.265743e-001, 2.018655e-001, 1.475498e-002
11315, -1.269974e-001, 2.024069e-001, 1.547625e-002
11316, -1.272669e-001, 2.030006e-001, 1.622793e-002
11317, -1.273757e-001, 2.036286e-001, 1.698763e-002
11318, -1.273225e-001, 2.042731e-001, 1.773451e-002
11319, -1.271102e-001, 2.049158e-001, 1.844979e-002
11320, -1.267457e-001, 2.055410e-001, 1.911456e-002
11321, -1.262381e-001, 2.061388e-001, 1.971020e-002
11322, -1.255989e-001, 2.066914e-001, 2.022224e-002
11323, -1.248452e-001, 2.071816e-001, 2.063656e-002
11324, -1.239980e-001, 2.075950e-001, 2.094101e-002
11325, -1.230806e-001, 2.079200e-001, 2.112699e-002
11326, -1.232172e-001, 2.086761e-001, 2.048234e-002
11327, -1.233540e-001, 2.094321e-001, 1.983760e-002
11328, -1.234912e-001, 2.101883e-001, 1.919261e-002
11329, -1.236287e-001, 2.109447e-001, 1.854732e-002
11330, -1.237660e-001, 2.117011e-001, 1.790213e-002
11331, -1.239028e-001, 2.124574e-001, 1.725714e-002
11332, -1.240395e-001, 2.132138e-001, 1.661220e-002
11333, -1.241761e-001, 2.139701e-001, 1.596726e-002
11334, -1.243128e-001, 2.147266e-001, 1.532227e-002
11335, -1.244495e-001, 2.154829e-001, 1.467727e-002
11336, -1.245865e-001, 2.162392e-001, 1.403227e-002
11337, -1.247235e-001, 2.169956e-001, 1.338724e-002
11338, -1.248602e-001, 2.177519e-001, 1.274226e-002
11339, -1.249966e-001, 2.185083e-001, 1.209740e-002
11340, -1.251334e-001, 2.192646e-001, 1.145243e-002
11341, -1.252725e-001, 2.200197e-001, 1.080760e-002
11342, -1.254126e-001, 2.207681e-001, 1.016764e-002
11343, -1.255521e-001, 2.215012e-001, 9.539995e-003
11344, -1.257063e-001, 2.222188e-001, 8.918995e-003
11345, -1.258928e-001, 2.229368e-001, 8.285225e-003
11346, -1.228689e-001, 2.234419e-001, 8.009602e-003
11347, -1.219318e-001, 2.233582e-001, 7.690711e-003
11348, -1.210827e-001, 2.231638e-001, 7.289813e-003
11349, -1.203599e-001, 2.228721e-001, 6.858283e-003
11350, -1.197690e-001, 2.225138e-001, 6.427811e-003
11351, -1.192972e-001, 2.221091e-001, 6.022102e-003
11352, -1.189273e-001, 2.216438e-001, 5.698637e-003
11353, -1.186365e-001, 2.210493e-001, 5.588516e-003
11354, -1.183846e-001, 2.203670e-001, 5.584796e-003
11355, -1.181599e-001, 2.196135e-001, 5.641671e-003
11356, -1.179622e-001, 2.188038e-001, 5.745869e-003
11357, -1.177913e-001, 2.179465e-001, 5.887718e-003
11358, -1.176479e-001, 2.170480e-001, 6.057503e-003
11359, -1.175344e-001, 2.161158e-001, 6.245473e-003
11360, -1.174540e-001, 2.151581e-001, 6.446011e-003
11361, -1.174100e-001, 2.141785e-001, 6.654952e-003
11362, -1.174071e-001, 2.131791e-001, 6.867944e-003
11363, -1.174522e-001, 2.121640e-001, 7.079050e-003
11364, -1.175552e-001, 2.111354e-001, 7.283520e-003
11365, -1.177306e-001, 2.100953e-001, 7.475795e-003
11366, -1.179960e-001, 2.090490e-001, 7.655684e-003
11367, -1.183557e-001, 2.080045e-001, 7.847284e-003
11368, -1.188210e-001, 2.068614e-001, 8.139951e-003
11369, -1.196151e-001, 2.061427e-001, 8.052236e-003
11370, -1.199569e-001, 2.050381e-001, 8.688898e-003
11371, -1.205394e-001, 2.046149e-001, 8.770896e-003
11372, -1.193603e-001, 2.089534e-001, 1.999041e-002
11373, -1.202992e-001, 2.090444e-001, 2.029534e-002
11374, -1.257801e-001, 2.066089e-001, 8.103714e-003
11375, -1.263811e-001, 2.074729e-001, 7.835925e-003
11376, -1.269454e-001, 2.083786e-001, 7.592762e-003
11377, -1.274563e-001, 2.093057e-001, 7.369275e-003
11378, -1.279072e-001, 2.102457e-001, 7.148692e-003
11379, -1.283033e-001, 2.111934e-001, 6.927963e-003
11380, -1.286506e-001, 2.121439e-001, 6.709534e-003
11381, -1.289535e-001, 2.130927e-001, 6.498276e-003
11382, -1.292152e-001, 2.140387e-001, 6.299020e-003
11383, -1.294369e-001, 2.149806e-001, 6.114841e-003
11384, -1.296172e-001, 2.159124e-001, 5.953846e-003
11385, -1.297511e-001, 2.168123e-001, 5.832678e-003
11386, -1.298351e-001, 2.176653e-001, 5.756367e-003
11387, -1.298691e-001, 2.184692e-001, 5.719831e-003
11388, -1.298496e-001, 2.192228e-001, 5.732850e-003
11389, -1.297632e-001, 2.199191e-001, 5.826877e-003
11390, -1.295752e-001, 2.205254e-001, 6.069292e-003
11391, -1.292816e-001, 2.210787e-001, 6.395157e-003
11392, -1.288711e-001, 2.216019e-001, 6.764102e-003
11393, -1.283362e-001, 2.221067e-001, 7.132005e-003
11394, -1.276943e-001, 2.225790e-001, 7.449731e-003
11395, -1.270335e-001, 2.229656e-001, 7.673583e-003
11396, -1.204350e-001, 2.098007e-001, 1.965025e-002
11397, -1.205707e-001, 2.105570e-001, 1.900507e-002
11398, -1.207064e-001, 2.113134e-001, 1.835978e-002
11399, -1.208421e-001, 2.120699e-001, 1.771445e-002
11400, -1.209781e-001, 2.128264e-001, 1.706919e-002
11401, -1.211143e-001, 2.135828e-001, 1.642409e-002
11402, -1.212502e-001, 2.143391e-001, 1.577901e-002
11403, -1.213863e-001, 2.150956e-001, 1.513385e-002
11404, -1.215227e-001, 2.158521e-001, 1.448874e-002
11405, -1.216599e-001, 2.166084e-001, 1.384400e-002
11406, -1.217962e-001, 2.173638e-001, 1.319983e-002
11407, -1.219302e-001, 2.181188e-001, 1.255530e-002
11408, -1.220665e-001, 2.188762e-001, 1.190938e-002
11409, -1.222046e-001, 2.196343e-001, 1.126332e-002
11410, -1.223411e-001, 2.203924e-001, 1.061670e-002
11411, -1.224737e-001, 2.211522e-001, 9.967495e-003
11412, -1.226045e-001, 2.219146e-001, 9.315349e-003
11413, -1.227359e-001, 2.226781e-001, 8.662355e-003
11414, -1.176881e-001, 2.084616e-001, 1.906188e-002
11415, -1.184819e-001, 2.087573e-001, 1.957544e-002
11416, -1.170001e-001, 2.080746e-001, 1.846346e-002
11417, -1.164367e-001, 2.076071e-001, 1.779635e-002
11418, -1.160134e-001, 2.070723e-001, 1.707851e-002
11419, -1.157417e-001, 2.064854e-001, 1.632883e-002
11420, -1.156287e-001, 2.058607e-001, 1.556813e-002
11421, -1.156775e-001, 2.052135e-001, 1.481823e-002
11422, -1.158868e-001, 2.045598e-001, 1.410204e-002
11423, -1.162489e-001, 2.039152e-001, 1.344430e-002
11424, -1.167492e-001, 2.032954e-001, 1.286902e-002
11425, -1.173714e-001, 2.027323e-001, 1.237953e-002
11426, -1.180964e-001, 2.023271e-001, 1.192298e-002
11427, -1.189496e-001, 2.018900e-001, 1.161489e-002
11428, -1.198587e-001, 2.016073e-001, 1.138559e-002
11429, -1.208678e-001, 2.014575e-001, 1.123555e-002
11430, -1.219441e-001, 2.012898e-001, 1.133359e-002
11431, -1.229114e-001, 2.012100e-001, 1.158929e-002
11432, -1.238400e-001, 2.012843e-001, 1.192110e-002
11433, -1.247029e-001, 2.014815e-001, 1.233937e-002
11434, -1.254903e-001, 2.017861e-001, 1.285219e-002
11435, -1.261802e-001, 2.021875e-001, 1.345703e-002
11436, -1.267437e-001, 2.026710e-001, 1.413623e-002
11437, -1.271623e-001, 2.032231e-001, 1.486957e-002
11438, -1.274210e-001, 2.038229e-001, 1.562530e-002
11439, -1.275167e-001, 2.044454e-001, 1.638194e-002
11440, -1.274529e-001, 2.050777e-001, 1.712362e-002
11441, -1.272345e-001, 2.057014e-001, 1.783326e-002
11442, -1.268711e-001, 2.063028e-001, 1.849080e-002
11443, -1.263687e-001, 2.068938e-001, 1.907534e-002
11444, -1.257332e-001, 2.074459e-001, 1.958120e-002
11445, -1.249811e-001, 2.079366e-001, 1.999325e-002
11446, -1.241344e-001, 2.083506e-001, 2.029682e-002
11447, -1.242714e-001, 2.091061e-001, 1.965233e-002
11448, -1.244096e-001, 2.098618e-001, 1.900690e-002
11449, -1.245494e-001, 2.106181e-001, 1.836014e-002
11450, -1.246875e-001, 2.113747e-001, 1.771418e-002
11451, -1.248241e-001, 2.121310e-001, 1.706931e-002
11452, -1.249604e-001, 2.128872e-001, 1.642472e-002
11453, -1.250968e-001, 2.136434e-001, 1.578003e-002
11454, -1.252337e-001, 2.143996e-001, 1.513505e-002
11455, -1.253715e-001, 2.151555e-001, 1.448979e-002
11456, -1.255101e-001, 2.159110e-001, 1.384432e-002
11457, -1.256481e-001, 2.166670e-001, 1.319884e-002
11458, -1.257847e-001, 2.174234e-001, 1.255389e-002
11459, -1.259200e-001, 2.181798e-001, 1.190974e-002
11460, -1.260573e-001, 2.189356e-001, 1.126479e-002
11461, -1.262018e-001, 2.196884e-001, 1.061783e-002
11462, -1.263408e-001, 2.204293e-001, 9.983058e-003
11463, -1.264605e-001, 2.211386e-001, 9.383219e-003
11464, -1.266075e-001, 2.218090e-001, 8.796146e-003
11465, -1.267890e-001, 2.224332e-001, 8.222040e-003
11466, -1.214527e-001, 2.046113e-001, 8.544000e-003
11467, -1.223603e-001, 2.044447e-001, 8.633983e-003
11468, -1.230453e-001, 2.047631e-001, 8.434471e-003
11469, -1.237883e-001, 2.050730e-001, 8.354699e-003
11470, -1.245043e-001, 2.053355e-001, 8.429276e-003
11471, -1.252364e-001, 2.058795e-001, 8.376568e-003
11472, -1.192927e-001, 2.054705e-001, 8.757450e-003
11473, -1.218044e-001, 2.225906e-001, 8.351542e-003
11474, -1.209687e-001, 2.224006e-001, 7.960659e-003
11475, -1.202643e-001, 2.221401e-001, 7.525919e-003
11476, -1.196950e-001, 2.218599e-001, 7.056163e-003
11477, -1.192662e-001, 2.216010e-001, 6.585002e-003
11478, -1.189853e-001, 2.213889e-001, 6.203258e-003
11479, -1.187910e-001, 2.209257e-001, 6.291557e-003
11480, -1.185572e-001, 2.203186e-001, 6.407472e-003
11481, -1.183134e-001, 2.196323e-001, 6.515104e-003
11482, -1.180846e-001, 2.188882e-001, 6.656775e-003
11483, -1.178701e-001, 2.180843e-001, 6.825583e-003
11484, -1.176717e-001, 2.172210e-001, 7.009619e-003
11485, -1.174959e-001, 2.163083e-001, 7.196181e-003
11486, -1.173500e-001, 2.153595e-001, 7.388807e-003
11487, -1.172379e-001, 2.143749e-001, 7.588666e-003
11488, -1.171647e-001, 2.133585e-001, 7.792416e-003
11489, -1.171403e-001, 2.123153e-001, 7.984082e-003
11490, -1.171757e-001, 2.112507e-001, 8.159732e-003
11491, -1.172855e-001, 2.101647e-001, 8.316628e-003
11492, -1.174824e-001, 2.090690e-001, 8.461705e-003
11493, -1.177539e-001, 2.080074e-001, 8.621112e-003
11494, -1.180457e-001, 2.070473e-001, 8.824592e-003
11495, -1.186803e-001, 2.060015e-001, 8.860118e-003
11496, -1.196657e-001, 2.044113e-001, 9.315810e-003
11497, -1.202689e-001, 2.041463e-001, 9.239250e-003
11498, -1.218290e-001, 2.041732e-001, 8.868880e-003
11499, -1.274228e-001, 2.082918e-001, 8.526748e-003
11500, -1.278692e-001, 2.092826e-001, 8.307651e-003
11501, -1.282577e-001, 2.102783e-001, 8.093725e-003
11502, -1.285928e-001, 2.112754e-001, 7.880496e-003
11503, -1.288775e-001, 2.122653e-001, 7.670578e-003
11504, -1.291156e-001, 2.132420e-001, 7.471905e-003
11505, -1.293102e-001, 2.142083e-001, 7.290422e-003
11506, -1.294629e-001, 2.151685e-001, 7.108656e-003
11507, -1.295706e-001, 2.160903e-001, 6.947842e-003
11508, -1.296320e-001, 2.169499e-001, 6.822813e-003
11509, -1.296506e-001, 2.177490e-001, 6.728696e-003
11510, -1.296409e-001, 2.184894e-001, 6.625242e-003
11511, -1.296095e-001, 2.191626e-001, 6.520710e-003
11512, -1.295578e-001, 2.197492e-001, 6.438937e-003
11513, -1.293758e-001, 2.201613e-001, 6.671356e-003
11514, -1.290940e-001, 2.205860e-001, 6.989886e-003
11515, -1.287004e-001, 2.210328e-001, 7.345808e-003
11516, -1.281816e-001, 2.215071e-001, 7.695068e-003
11517, -1.275375e-001, 2.219830e-001, 8.000106e-003
11518, -1.194957e-001, 2.097093e-001, 1.934520e-002
11519, -1.196309e-001, 2.104654e-001, 1.869973e-002
11520, -1.197658e-001, 2.112216e-001, 1.805395e-002
11521, -1.199008e-001, 2.119781e-001, 1.740809e-002
11522, -1.200364e-001, 2.127344e-001, 1.676263e-002
11523, -1.201715e-001, 2.134902e-001, 1.611736e-002
11524, -1.203045e-001, 2.142455e-001, 1.547143e-002
11525, -1.204392e-001, 2.150020e-001, 1.482525e-002
11526, -1.205764e-001, 2.157590e-001, 1.418010e-002
11527, -1.207162e-001, 2.165148e-001, 1.353742e-002
11528, -1.208520e-001, 2.172670e-001, 1.289597e-002
11529, -1.209786e-001, 2.180175e-001, 1.225115e-002
11530, -1.211169e-001, 2.187788e-001, 1.160239e-002
11531, -1.212637e-001, 2.195412e-001, 1.095722e-002
11532, -1.214090e-001, 2.203007e-001, 1.031405e-002
11533, -1.215472e-001, 2.210613e-001, 9.665971e-003
11534, -1.216807e-001, 2.218255e-001, 9.011855e-003
11535, -1.161513e-001, 2.078321e-001, 1.643359e-002
11536, -1.165739e-001, 2.083643e-001, 1.715167e-002
11537, -1.269569e-001, 2.073058e-001, 8.831167e-003
11538, -1.232024e-001, 2.041849e-001, 8.984092e-003
11539, -1.239062e-001, 2.044919e-001, 8.935812e-003
11540, -1.171361e-001, 2.088302e-001, 1.781837e-002
11541, -1.178234e-001, 2.092169e-001, 1.841652e-002
11542, -1.158800e-001, 2.072493e-001, 1.568193e-002
11543, -1.157667e-001, 2.066258e-001, 1.491831e-002
11544, -1.158156e-001, 2.059764e-001, 1.416641e-002
11545, -1.160251e-001, 2.053168e-001, 1.345173e-002
11546, -1.163853e-001, 2.046612e-001, 1.280476e-002
11547, -1.168723e-001, 2.040163e-001, 1.226548e-002
11548, -1.174377e-001, 2.034083e-001, 1.186851e-002
11549, -1.180805e-001, 2.033152e-001, 1.125488e-002
11550, -1.190028e-001, 2.026472e-001, 1.102066e-002
11551, -1.198540e-001, 2.024072e-001, 1.076269e-002
11552, -1.209269e-001, 2.025363e-001, 1.033908e-002
11553, -1.222861e-001, 2.021573e-001, 1.061234e-002
11554, -1.231516e-001, 2.019459e-001, 1.099628e-002
11555, -1.240644e-001, 2.020397e-001, 1.132788e-002
11556, -1.249184e-001, 2.022730e-001, 1.172875e-002
11557, -1.257103e-001, 2.026168e-001, 1.223442e-002
11558, -1.264035e-001, 2.030452e-001, 1.285634e-002
11559, -1.269609e-001, 2.035437e-001, 1.357080e-002
11560, -1.273564e-001, 2.041044e-001, 1.431485e-002
11561, -1.275884e-001, 2.047058e-001, 1.506204e-002
11562, -1.276577e-001, 2.053010e-001, 1.581390e-002
11563, -1.275748e-001, 2.059069e-001, 1.655006e-002
11564, -1.273454e-001, 2.064960e-001, 1.725193e-002
11565, -1.269876e-001, 2.070393e-001, 1.789712e-002
11566, -1.264991e-001, 2.076352e-001, 1.844864e-002
11567, -1.258691e-001, 2.081960e-001, 1.894125e-002
11568, -1.251180e-001, 2.086906e-001, 1.934973e-002
11569, -1.252589e-001, 2.094447e-001, 1.870278e-002
11570, -1.255454e-001, 2.109583e-001, 1.740109e-002
11571, -1.254061e-001, 2.101995e-001, 1.804996e-002
11572, -1.264456e-001, 2.063119e-001, 9.174876e-003
11573, -1.256798e-001, 2.117161e-001, 1.675703e-002
11574, -1.258142e-001, 2.124722e-001, 1.611421e-002
11575, -1.259499e-001, 2.132270e-001, 1.547110e-002
11576, -1.260883e-001, 2.139811e-001, 1.482629e-002
11577, -1.262299e-001, 2.147337e-001, 1.417974e-002
11578, -1.263737e-001, 2.154859e-001, 1.353160e-002
11579, -1.265138e-001, 2.162420e-001, 1.288394e-002
11580, -1.266487e-001, 2.169997e-001, 1.223956e-002
11581, -1.267800e-001, 2.177571e-001, 1.159842e-002
11582, -1.269200e-001, 2.185125e-001, 1.095124e-002
11583, -1.270837e-001, 2.192647e-001, 1.028609e-002
11584, -1.272182e-001, 2.200157e-001, 9.646679e-003
11585, -1.272595e-001, 2.207206e-001, 9.118670e-003
11586, -1.273870e-001, 2.213674e-001, 8.558149e-003
11587, -1.186171e-001, 2.095128e-001, 1.893011e-002
11588, -1.245587e-001, 2.047240e-001, 9.044628e-003
11589, -1.210058e-001, 2.042087e-001, 8.959897e-003
11590, -1.225508e-001, 2.039409e-001, 9.084952e-003
11591, -1.257912e-001, 2.055748e-001, 9.180895e-003
11592, -1.250847e-001, 2.052347e-001, 8.899837e-003
11593, -1.188905e-001, 2.046399e-001, 9.646683e-003
11594, -1.208457e-001, 2.216412e-001, 8.620162e-003
11595, -1.201275e-001, 2.214007e-001, 8.152720e-003
11596, -1.195272e-001, 2.211647e-001, 7.581175e-003
11597, -1.190881e-001, 2.210215e-001, 6.921811e-003
11598, -1.188344e-001, 2.203478e-001, 7.185870e-003
11599, -1.185458e-001, 2.196846e-001, 7.286679e-003
11600, -1.183095e-001, 2.190010e-001, 7.496410e-003
11601, -1.180684e-001, 2.182436e-001, 7.725517e-003
11602, -1.178199e-001, 2.174008e-001, 7.949100e-003
11603, -1.175780e-001, 2.164926e-001, 8.138564e-003
11604, -1.173659e-001, 2.155517e-001, 8.335209e-003
11605, -1.171835e-001, 2.145662e-001, 8.550141e-003
11606, -1.170337e-001, 2.135284e-001, 8.770540e-003
11607, -1.169320e-001, 2.124549e-001, 8.947881e-003
11608, -1.168910e-001, 2.113628e-001, 9.098503e-003
11609, -1.169216e-001, 2.102464e-001, 9.230169e-003
11610, -1.170336e-001, 2.091121e-001, 9.355466e-003
11611, -1.172270e-001, 2.080008e-001, 9.486133e-003
11612, -1.175213e-001, 2.069621e-001, 9.576611e-003
11613, -1.181876e-001, 2.063818e-001, 9.090955e-003
11614, -1.195866e-001, 2.038558e-001, 9.778085e-003
11615, -1.202493e-001, 2.033801e-001, 9.847738e-003
11616, -1.220559e-001, 2.037857e-001, 9.191324e-003
11617, -1.278333e-001, 2.082652e-001, 9.606248e-003
11618, -1.281928e-001, 2.093137e-001, 9.342558e-003
11619, -1.260162e-001, 2.051247e-001, 9.909330e-003
11620, -1.265453e-001, 2.057640e-001, 9.931316e-003
11621, -1.285060e-001, 2.103583e-001, 9.106733e-003
11622, -1.287697e-001, 2.113944e-001, 8.880281e-003
11623, -1.289862e-001, 2.124205e-001, 8.663055e-003
11624, -1.291550e-001, 2.134223e-001, 8.466243e-003
11625, -1.292754e-001, 2.144081e-001, 8.310283e-003
11626, -1.293586e-001, 2.153880e-001, 8.106481e-003
11627, -1.294001e-001, 2.162828e-001, 7.919249e-003
11628, -1.294015e-001, 2.170917e-001, 7.772922e-003
11629, -1.293504e-001, 2.178724e-001, 7.693764e-003
11630, -1.293189e-001, 2.186060e-001, 7.493159e-003
11631, -1.293003e-001, 2.192517e-001, 7.255817e-003
11632, -1.292724e-001, 2.198158e-001, 7.050774e-003
11633, -1.289767e-001, 2.200890e-001, 7.460842e-003
11634, -1.285735e-001, 2.204731e-001, 7.858964e-003
11635, -1.280364e-001, 2.209222e-001, 8.237382e-003
11636, -1.187519e-001, 2.102685e-001, 1.828429e-002
11637, -1.207391e-001, 2.037502e-001, 9.397485e-003
11638, -1.162920e-001, 2.086002e-001, 1.578832e-002
11639, -1.167131e-001, 2.091256e-001, 1.650734e-002
11640, -1.188863e-001, 2.110244e-001, 1.763790e-002
11641, -1.190211e-001, 2.117804e-001, 1.699175e-002
11642, -1.191566e-001, 2.125357e-001, 1.634685e-002
11643, -1.192877e-001, 2.132888e-001, 1.570055e-002
11644, -1.194106e-001, 2.140386e-001, 1.505036e-002
11645, -1.195444e-001, 2.147972e-001, 1.440076e-002
11646, -1.196870e-001, 2.155570e-001, 1.375743e-002
11647, -1.198360e-001, 2.163128e-001, 1.312376e-002
11648, -1.199720e-001, 2.170562e-001, 1.249127e-002
11649, -1.200714e-001, 2.177856e-001, 1.184143e-002
11650, -1.202187e-001, 2.185652e-001, 1.118231e-002
11651, -1.203880e-001, 2.193440e-001, 1.054285e-002
11652, -1.205527e-001, 2.201097e-001, 9.912332e-003
11653, -1.207036e-001, 2.208740e-001, 9.271380e-003
11654, -1.264548e-001, 2.112250e-001, 1.631389e-002
11655, -1.263303e-001, 2.104540e-001, 1.695406e-002
11656, -1.273978e-001, 2.072401e-001, 9.790810e-003
11657, -1.226925e-001, 2.035592e-001, 9.437970e-003
11658, -1.233567e-001, 2.037143e-001, 9.451654e-003
11659, -1.240366e-001, 2.040512e-001, 9.404709e-003
11660, -1.160205e-001, 2.080227e-001, 1.503373e-002
11661, -1.161669e-001, 2.060746e-001, 1.279038e-002
11662, -1.159548e-001, 2.067426e-001, 1.350873e-002
11663, -1.165330e-001, 2.054164e-001, 1.213699e-002
11664, -1.170289e-001, 2.047385e-001, 1.160920e-002
11665, -1.176068e-001, 2.041704e-001, 1.118169e-002
11666, -1.185113e-001, 2.038941e-001, 1.047537e-002
11667, -1.191416e-001, 2.031996e-001, 1.052548e-002
11668, -1.196661e-001, 2.030239e-001, 1.037064e-002
11669, -1.214936e-001, 2.034180e-001, 9.528669e-003
11670, -1.224961e-001, 2.030252e-001, 9.879016e-003
11671, -1.234690e-001, 2.025725e-001, 1.053609e-002
11672, -1.243168e-001, 2.027918e-001, 1.075788e-002
11673, -1.251706e-001, 2.031039e-001, 1.111485e-002
11674, -1.259981e-001, 2.035406e-001, 1.161206e-002
11675, -1.267025e-001, 2.039952e-001, 1.230896e-002
11676, -1.272180e-001, 2.044787e-001, 1.306723e-002
11677, -1.275672e-001, 2.050404e-001, 1.379268e-002
11678, -1.277663e-001, 2.056621e-001, 1.453171e-002
11679, -1.277906e-001, 2.061627e-001, 1.530013e-002
11680, -1.276825e-001, 2.067422e-001, 1.602943e-002
11681, -1.274351e-001, 2.073027e-001, 1.672273e-002
11682, -1.270971e-001, 2.076836e-001, 1.736203e-002
11683, -1.266457e-001, 2.083486e-001, 1.781283e-002
11684, -1.260155e-001, 2.089395e-001, 1.829336e-002
11685, -1.265827e-001, 2.119834e-001, 1.567776e-002
11686, -1.246542e-001, 2.042300e-001, 9.581571e-003
11687, -1.172728e-001, 2.095870e-001, 1.717304e-002
11688, -1.261841e-001, 2.096849e-001, 1.761834e-002
11689, -1.269694e-001, 2.065330e-001, 9.759518e-003
11690, -1.267152e-001, 2.127321e-001, 1.504257e-002
11691, -1.268563e-001, 2.134748e-001, 1.440130e-002
11692, -1.270059e-001, 2.142128e-001, 1.375299e-002
11693, -1.271660e-001, 2.149508e-001, 1.309221e-002
11694, -1.273086e-001, 2.157146e-001, 1.243549e-002
11695, -1.274373e-001, 2.164824e-001, 1.179267e-002
11696, -1.275604e-001, 2.172462e-001, 1.115884e-002
11697, -1.277127e-001, 2.180001e-001, 1.049713e-002
11698, -1.279465e-001, 2.187527e-001, 9.737798e-003
11699, -1.281316e-001, 2.195907e-001, 8.981677e-003
11700, -1.278942e-001, 2.203552e-001, 8.763912e-003
11701, -1.253270e-001, 2.046238e-001, 9.709851e-003
11702, -1.159058e-001, 2.073974e-001, 1.426515e-002
11703, -1.214363e-001, 2.039489e-001, 9.093964e-003
11704, -1.183020e-001, 2.053982e-001, 9.626693e-003
11705, -1.179586e-001, 2.099725e-001, 1.777055e-002
11706, -1.178416e-001, 2.061483e-001, 9.641811e-003
11707, -1.199458e-001, 2.206130e-001, 8.777379e-003
11708, -1.192405e-001, 2.202808e-001, 8.118995e-003
11709, -1.187888e-001, 2.197084e-001, 7.900157e-003
