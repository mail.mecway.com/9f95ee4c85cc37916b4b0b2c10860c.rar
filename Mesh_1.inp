11710, -1.186431e-001, 2.191658e-001, 8.248795e-003
11711, -1.184024e-001, 2.184444e-001, 8.577382e-003
11712, -1.181066e-001, 2.175882e-001, 8.882180e-003
11713, -1.177706e-001, 2.166458e-001, 9.046794e-003
11714, -1.175019e-001, 2.157334e-001, 9.266083e-003
11715, -1.172567e-001, 2.147595e-001, 9.530976e-003
11716, -1.170257e-001, 2.136880e-001, 9.817031e-003
11717, -1.168342e-001, 2.125720e-001, 9.963440e-003
11718, -1.167095e-001, 2.114679e-001, 1.009178e-002
11719, -1.166514e-001, 2.103431e-001, 1.021187e-002
11720, -1.166644e-001, 2.091812e-001, 1.034300e-002
11721, -1.167420e-001, 2.080266e-001, 1.051230e-002
11722, -1.170593e-001, 2.067600e-001, 1.044136e-002
11723, -1.192874e-001, 2.035286e-001, 1.019268e-002
11724, -1.280882e-001, 2.082430e-001, 1.069341e-002
11725, -1.283965e-001, 2.094003e-001, 1.043510e-002
11726, -1.172229e-001, 2.053877e-001, 1.093969e-002
11727, -1.166912e-001, 2.062279e-001, 1.142068e-002
11728, -1.174114e-001, 2.103449e-001, 1.652982e-002
11729, -1.180942e-001, 2.107285e-001, 1.712472e-002
11730, -1.289691e-001, 2.126051e-001, 9.670106e-003
11731, -1.290680e-001, 2.136231e-001, 9.446828e-003
11732, -1.290848e-001, 2.146100e-001, 9.400212e-003
11733, -1.291187e-001, 2.156576e-001, 9.074918e-003
11734, -1.291258e-001, 2.164940e-001, 8.800670e-003
11735, -1.291006e-001, 2.171729e-001, 8.615054e-003
11736, -1.288406e-001, 2.188929e-001, 8.341765e-003
11737, -1.289272e-001, 2.195028e-001, 7.863223e-003
11738, -1.285029e-001, 2.198985e-001, 8.302595e-003
11739, -1.182308e-001, 2.114840e-001, 1.648062e-002
11740, -1.183667e-001, 2.122365e-001, 1.583901e-002
11741, -1.271415e-001, 2.106713e-001, 1.571230e-002
11742, -1.270358e-001, 2.098418e-001, 1.634830e-002
11743, -1.178257e-001, 2.048133e-001, 1.051553e-002
11744, -1.276533e-001, 2.135857e-001, 1.325082e-002
11745, -1.274994e-001, 2.128970e-001, 1.388464e-002
11746, -1.286325e-001, 2.104805e-001, 1.016524e-002
11747, -1.184878e-001, 2.129783e-001, 1.519023e-002
11748, -1.185826e-001, 2.137048e-001, 1.452439e-002
11749, -1.187272e-001, 2.144827e-001, 1.386640e-002
11750, -1.188859e-001, 2.152554e-001, 1.323188e-002
11751, -1.190569e-001, 2.160156e-001, 1.262601e-002
11752, -1.192023e-001, 2.167416e-001, 1.202451e-002
11753, -1.191966e-001, 2.173642e-001, 1.134299e-002
11754, -1.193809e-001, 2.182292e-001, 1.064201e-002
11755, -1.195966e-001, 2.190588e-001, 1.001848e-002
11756, -1.197886e-001, 2.198411e-001, 9.413939e-003
11757, -1.268713e-001, 2.090412e-001, 1.706322e-002
11758, -1.276028e-001, 2.069293e-001, 1.078049e-002
11759, -1.234619e-001, 2.031885e-001, 9.966576e-003
11760, -1.163103e-001, 2.068240e-001, 1.212701e-002
11761, -1.160949e-001, 2.075164e-001, 1.284734e-002
11762, -1.245072e-001, 2.036132e-001, 1.008430e-002
11763, -1.253719e-001, 2.039642e-001, 1.042525e-002
11764, -1.263335e-001, 2.046340e-001, 1.088303e-002
11765, -1.270450e-001, 2.050121e-001, 1.181272e-002
11766, -1.274646e-001, 2.053883e-001, 1.260832e-002
11767, -1.277750e-001, 2.059978e-001, 1.326851e-002
11768, -1.279741e-001, 2.068769e-001, 1.401769e-002
11769, -1.278993e-001, 2.069493e-001, 1.489342e-002
11770, -1.277724e-001, 2.075568e-001, 1.556631e-002
11771, -1.274562e-001, 2.081550e-001, 1.634262e-002
11772, -1.273652e-001, 2.121872e-001, 1.449915e-002
11773, -1.272494e-001, 2.114498e-001, 1.510065e-002
11774, -1.168569e-001, 2.098926e-001, 1.586776e-002
11775, -1.191364e-001, 2.040949e-001, 9.868473e-003
11776, -1.278619e-001, 2.142623e-001, 1.253374e-002
11777, -1.280050e-001, 2.150769e-001, 1.184579e-002
11778, -1.281262e-001, 2.158836e-001, 1.119830e-002
11779, -1.282369e-001, 2.166655e-001, 1.058104e-002
11780, -1.284023e-001, 2.173892e-001, 9.907713e-003
11781, -1.287992e-001, 2.180447e-001, 8.861100e-003
11782, -1.160459e-001, 2.081770e-001, 1.361192e-002
11783, -1.164382e-001, 2.093811e-001, 1.514740e-002
11784, -1.288221e-001, 2.115418e-001, 9.912177e-003
11785, -1.269136e-001, 2.056207e-001, 1.074959e-002
11786, -1.161645e-001, 2.088099e-001, 1.438968e-002
11787, -1.174252e-001, 2.059326e-001, 1.032401e-002
11788, -1.270015e-001, 2.061390e-001, 1.029607e-002
11789, -1.191306e-001, 2.195138e-001, 8.823292e-003
11790, -1.189103e-001, 2.187268e-001, 9.354812e-003
11791, -1.282465e-001, 2.083390e-001, 1.202263e-002
11792, -1.284711e-001, 2.096021e-001, 1.158266e-002
11793, -1.186173e-001, 2.177940e-001, 9.910740e-003
11794, -1.180315e-001, 2.167132e-001, 9.887774e-003
11795, -1.177590e-001, 2.159172e-001, 1.014959e-002
11796, -1.174831e-001, 2.149928e-001, 1.050642e-002
11797, -1.171817e-001, 2.138407e-001, 1.101421e-002
11798, -1.168481e-001, 2.126366e-001, 1.100582e-002
11799, -1.166400e-001, 2.115578e-001, 1.111914e-002
11800, -1.164936e-001, 2.104561e-001, 1.123553e-002
11801, -1.164023e-001, 2.092970e-001, 1.140515e-002
11802, -1.164319e-001, 2.075337e-001, 1.154199e-002
11803, -1.276366e-001, 2.090691e-001, 1.552516e-002
11804, -1.286769e-001, 2.152461e-001, 1.044204e-002
11805, -1.287510e-001, 2.160794e-001, 9.907905e-003
11806, -1.288332e-001, 2.167362e-001, 9.428800e-003
11807, -1.175547e-001, 2.111042e-001, 1.589338e-002
11808, -1.176945e-001, 2.118513e-001, 1.526508e-002
11809, -1.279700e-001, 2.123443e-001, 1.332359e-002
11810, -1.278687e-001, 2.116676e-001, 1.385616e-002
11811, -1.280834e-001, 2.129086e-001, 1.281815e-002
11812, -1.178093e-001, 2.125696e-001, 1.462555e-002
11813, -1.178216e-001, 2.131943e-001, 1.390283e-002
11814, -1.180296e-001, 2.140876e-001, 1.323107e-002
11815, -1.182081e-001, 2.148866e-001, 1.261368e-002
11816, -1.184123e-001, 2.156669e-001, 1.206258e-002
11817, -1.186164e-001, 2.163573e-001, 1.161043e-002
11818, -1.184743e-001, 2.170538e-001, 1.052304e-002
11819, -1.279145e-001, 2.071693e-001, 1.172842e-002
11820, -1.165918e-001, 2.101754e-001, 1.451819e-002
11821, -1.170073e-001, 2.106625e-001, 1.524226e-002
11822, -1.162366e-001, 2.083190e-001, 1.218032e-002
11823, -1.274426e-001, 2.060835e-001, 1.147756e-002
11824, -1.276314e-001, 2.060658e-001, 1.222605e-002
11825, -1.278979e-001, 2.067035e-001, 1.262308e-002
11826, -1.280319e-001, 2.077583e-001, 1.429795e-002
11827, -1.278936e-001, 2.083257e-001, 1.497816e-002
11828, -1.277818e-001, 2.109259e-001, 1.438698e-002
11829, -1.277066e-001, 2.100980e-001, 1.492596e-002
11830, -1.285487e-001, 2.143565e-001, 1.112281e-002
11831, -1.286271e-001, 2.106649e-001, 1.123575e-002
11832, -1.287439e-001, 2.117221e-001, 1.094501e-002
11833, -1.161866e-001, 2.089624e-001, 1.296141e-002
11834, -1.163157e-001, 2.096221e-001, 1.375889e-002
11835, -1.288823e-001, 2.137508e-001, 1.031938e-002
11836, -1.189731e-001, 2.038325e-001, 1.017043e-002
11837, -1.288151e-001, 2.128264e-001, 1.069444e-002
11838, -1.277062e-001, 2.065423e-001, 1.176816e-002
11839, -1.163234e-001, 2.097210e-001, 1.231914e-002
11840, -1.164893e-001, 2.105073e-001, 1.316516e-002
11841, -1.284861e-001, 2.109311e-001, 1.224884e-002
11842, -1.285332e-001, 2.119055e-001, 1.195217e-002
11843, -1.171602e-001, 2.114127e-001, 1.464944e-002
11844, -1.173075e-001, 2.120913e-001, 1.413588e-002
11845, -1.181511e-001, 2.161759e-001, 1.091351e-002
11846, -1.178909e-001, 2.153450e-001, 1.135001e-002
11847, -1.176595e-001, 2.144776e-001, 1.188627e-002
11848, -1.169439e-001, 2.126084e-001, 1.197247e-002
11849, -1.166882e-001, 2.116325e-001, 1.215770e-002
11850, -1.164603e-001, 2.105783e-001, 1.224176e-002
11851, -1.167560e-001, 2.109868e-001, 1.390705e-002
11852, -1.282573e-001, 2.119485e-001, 1.280794e-002
11853, -1.284346e-001, 2.132660e-001, 1.184530e-002
11854, -1.172449e-001, 2.128355e-001, 1.292425e-002
11855, -1.175121e-001, 2.137243e-001, 1.249627e-002
11856, -1.282265e-001, 2.112416e-001, 1.313546e-002
11857, -1.281635e-001, 2.104653e-001, 1.355850e-002
11858, -1.281069e-001, 2.075538e-001, 1.310833e-002
11859, -1.281489e-001, 2.083236e-001, 1.371215e-002
11860, -1.280911e-001, 2.096522e-001, 1.400041e-002
11861, -1.280262e-001, 2.088497e-001, 1.438442e-002
11862, -1.283975e-001, 2.100237e-001, 1.263573e-002
11863, -1.169020e-001, 2.117470e-001, 1.329697e-002
11864, -1.282802e-001, 2.090911e-001, 1.311013e-002
11865, -1.171893e-001, 2.133920e-001, 1.185070e-002
11866, -1.469192e-001, 2.554734e-001, 7.179338e-004
11867, -1.465461e-001, 2.551234e-001, 1.033631e-003
11868, -1.463923e-001, 2.547389e-001, 1.661421e-003
11869, -1.462976e-001, 2.540069e-001, 2.533734e-003
11870, -1.455703e-001, 2.531323e-001, 2.856596e-003
11871, -1.449589e-001, 2.522951e-001, 3.147498e-003
11872, -1.443858e-001, 2.514550e-001, 3.396711e-003
11873, -1.438255e-001, 2.506107e-001, 3.598957e-003
11874, -1.432764e-001, 2.497623e-001, 3.758415e-003
11875, -1.427380e-001, 2.489074e-001, 3.877832e-003
11876, -1.422131e-001, 2.480461e-001, 3.957732e-003
11877, -1.416804e-001, 2.471815e-001, 3.995917e-003
11878, -1.411654e-001, 2.463188e-001, 3.993537e-003
11879, -1.406841e-001, 2.454546e-001, 3.945858e-003
11880, -1.402540e-001, 2.445786e-001, 3.838963e-003
11881, -1.397900e-001, 2.436984e-001, 3.676774e-003
11882, -1.393644e-001, 2.428486e-001, 3.450024e-003
11883, -1.389903e-001, 2.420641e-001, 3.162289e-003
11884, -1.388181e-001, 2.413210e-001, 2.693370e-003
11885, -1.385784e-001, 2.406516e-001, 2.160976e-003
11886, -1.383902e-001, 2.401370e-001, 1.572449e-003
11887, -1.383841e-001, 2.398454e-001, 8.307454e-004
11888, -1.488276e-001, 2.567587e-001, 9.527443e-004
11889, -1.494400e-001, 2.571872e-001, 9.651641e-004
11890, -1.501695e-001, 2.576972e-001, 9.808000e-004
11891, -1.509562e-001, 2.582500e-001, 9.880308e-004
11892, -1.517652e-001, 2.588205e-001, 9.895523e-004
11893, -1.525808e-001, 2.593959e-001, 9.897741e-004
11894, -1.533982e-001, 2.599728e-001, 9.897505e-004
11895, -1.542161e-001, 2.605500e-001, 9.897126e-004
11896, -1.550342e-001, 2.611273e-001, 9.897038e-004
11897, -1.558524e-001, 2.617046e-001, 9.897301e-004
11898, -1.566705e-001, 2.622820e-001, 9.897242e-004
11899, -1.574886e-001, 2.628593e-001, 9.897034e-004
11900, -1.583068e-001, 2.634367e-001, 9.897066e-004
11901, -1.591249e-001, 2.640140e-001, 9.896965e-004
11902, -1.599431e-001, 2.645914e-001, 9.897144e-004
11903, -1.607612e-001, 2.651687e-001, 9.897138e-004
11904, -1.615794e-001, 2.657461e-001, 9.897134e-004
11905, -1.623975e-001, 2.663234e-001, 9.897080e-004
11906, -1.632157e-001, 2.669008e-001, 9.897142e-004
11907, -1.640339e-001, 2.674781e-001, 9.897117e-004
11908, -1.648520e-001, 2.680555e-001, 9.897105e-004
11909, -1.656702e-001, 2.686328e-001, 9.897125e-004
11910, -1.664883e-001, 2.692102e-001, 9.897153e-004
11911, -1.673065e-001, 2.697875e-001, 9.897175e-004
11912, -1.681246e-001, 2.703649e-001, 9.897187e-004
11913, -1.689428e-001, 2.709422e-001, 9.897194e-004
11914, -1.697609e-001, 2.715196e-001, 9.897197e-004
11915, -1.705791e-001, 2.720970e-001, 9.897199e-004
11916, -1.713972e-001, 2.726743e-001, 9.897200e-004
11917, -1.722154e-001, 2.732517e-001, 9.897201e-004
11918, -1.730335e-001, 2.738290e-001, 9.897202e-004
11919, -1.738517e-001, 2.744064e-001, 9.897203e-004
11920, -1.746699e-001, 2.749837e-001, 9.897203e-004
11921, -1.754880e-001, 2.755611e-001, 9.897204e-004
11922, -1.763062e-001, 2.761384e-001, 9.897205e-004
11923, -1.771243e-001, 2.767158e-001, 9.897206e-004
11924, -1.779425e-001, 2.772931e-001, 9.897206e-004
11925, -1.787606e-001, 2.778705e-001, 9.897207e-004
11926, -1.795788e-001, 2.784478e-001, 9.897208e-004
11927, -1.803969e-001, 2.790252e-001, 9.897209e-004
11928, -1.812151e-001, 2.796025e-001, 9.897209e-004
11929, -1.820332e-001, 2.801799e-001, 9.897210e-004
11930, -1.828514e-001, 2.807572e-001, 9.897211e-004
11931, -1.836695e-001, 2.813346e-001, 9.897211e-004
11932, -1.844877e-001, 2.819119e-001, 9.897212e-004
11933, -1.853058e-001, 2.824893e-001, 9.897213e-004
11934, -1.861240e-001, 2.830666e-001, 9.897214e-004
11935, -1.869422e-001, 2.836440e-001, 9.897214e-004
11936, -1.877603e-001, 2.842213e-001, 9.897215e-004
11937, -1.885785e-001, 2.847987e-001, 9.897216e-004
11938, -1.893966e-001, 2.853760e-001, 9.897217e-004
11939, -1.902148e-001, 2.859534e-001, 9.897217e-004
11940, -1.910329e-001, 2.865307e-001, 9.897218e-004
11941, -1.918511e-001, 2.871081e-001, 9.897219e-004
11942, -1.926692e-001, 2.876854e-001, 9.897219e-004
11943, -1.934874e-001, 2.882628e-001, 9.897220e-004
11944, -1.943055e-001, 2.888401e-001, 9.897221e-004
11945, -1.951237e-001, 2.894175e-001, 9.897222e-004
11946, -1.959418e-001, 2.899948e-001, 9.897222e-004
11947, -1.967600e-001, 2.905722e-001, 9.897223e-004
11948, -1.975781e-001, 2.911495e-001, 9.897224e-004
11949, -1.983963e-001, 2.917269e-001, 9.897224e-004
11950, -1.992145e-001, 2.923043e-001, 9.897225e-004
11951, -2.000326e-001, 2.928816e-001, 9.897226e-004
11952, -2.008508e-001, 2.934590e-001, 9.897230e-004
11953, -2.016689e-001, 2.940363e-001, 9.897231e-004
11954, -2.024871e-001, 2.946137e-001, 9.897232e-004
11955, -2.033052e-001, 2.951910e-001, 9.897232e-004
11956, -2.041234e-001, 2.957684e-001, 9.897233e-004
11957, -2.049415e-001, 2.963457e-001, 9.897233e-004
11958, -2.057597e-001, 2.969231e-001, 9.897234e-004
11959, -2.065778e-001, 2.975004e-001, 9.897234e-004
11960, -2.073960e-001, 2.980778e-001, 9.897235e-004
11961, -2.082141e-001, 2.986551e-001, 9.897235e-004
11962, -2.090323e-001, 2.992325e-001, 9.897236e-004
11963, -2.098504e-001, 2.998098e-001, 9.897236e-004
11964, -2.106686e-001, 3.003872e-001, 9.897237e-004
11965, -2.114867e-001, 3.009645e-001, 9.897237e-004
11966, -2.123049e-001, 3.015419e-001, 9.897238e-004
11967, -2.131231e-001, 3.021192e-001, 9.897238e-004
11968, -2.139412e-001, 3.026966e-001, 9.897239e-004
11969, -2.147594e-001, 3.032739e-001, 9.897239e-004
11970, -2.155775e-001, 3.038513e-001, 9.897240e-004
11971, -2.163957e-001, 3.044286e-001, 9.897240e-004
11972, -2.172138e-001, 3.050060e-001, 9.897241e-004
11973, -2.180320e-001, 3.055833e-001, 9.897241e-004
11974, -2.188501e-001, 3.061607e-001, 9.897242e-004
11975, -2.196683e-001, 3.067380e-001, 9.897243e-004
11976, -2.204864e-001, 3.073154e-001, 9.897243e-004
11977, -2.213046e-001, 3.078927e-001, 9.897244e-004
11978, -2.221227e-001, 3.084701e-001, 9.897245e-004
11979, -2.229409e-001, 3.090474e-001, 9.897245e-004
11980, -2.237590e-001, 3.096248e-001, 9.897246e-004
11981, -2.245772e-001, 3.102021e-001, 9.897247e-004
11982, -2.253954e-001, 3.107795e-001, 9.897251e-004
11983, -2.262135e-001, 3.113568e-001, 9.897315e-004
11984, -2.270318e-001, 3.119343e-001, 9.897248e-004
11985, -2.278499e-001, 3.125116e-001, 9.895934e-004
11986, -2.286680e-001, 3.130890e-001, 9.894652e-004
11987, -2.294861e-001, 3.136663e-001, 9.893975e-004
11988, -2.303042e-001, 3.142437e-001, 9.893731e-004
11989, -2.311224e-001, 3.148211e-001, 9.893099e-004
11990, -2.319405e-001, 3.153984e-001, 9.892309e-004
11991, -2.327587e-001, 3.159758e-001, 9.892726e-004
11992, -2.335768e-001, 3.165531e-001, 9.893997e-004
11993, -2.343950e-001, 3.171304e-001, 9.895274e-004
11994, -2.352132e-001, 3.177078e-001, 9.896539e-004
11995, -2.360314e-001, 3.182852e-001, 9.895604e-004
11996, -2.368495e-001, 3.188625e-001, 9.894040e-004
11997, -2.376676e-001, 3.194399e-001, 9.892679e-004
11998, -2.384861e-001, 3.200173e-001, 9.897227e-004
11999, -2.393040e-001, 3.205943e-001, 9.902143e-004
12000, -2.401201e-001, 3.211707e-001, 9.886822e-004
12001, -2.409356e-001, 3.217466e-001, 9.871721e-004
12002, -2.417544e-001, 3.223239e-001, 9.892072e-004
12003, -2.425800e-001, 3.229041e-001, 9.968117e-004
12004, -2.434003e-001, 3.234811e-001, 1.002449e-003
12005, -2.442119e-001, 3.240500e-001, 1.014777e-003
12006, -2.450342e-001, 3.246209e-001, 1.043402e-003
12007, -2.458875e-001, 3.252147e-001, 1.068171e-003
12008, -2.467581e-001, 3.258258e-001, 1.077892e-003
12009, -2.475556e-001, 3.264280e-001, 9.554229e-004
12010, -2.482975e-001, 3.269794e-001, 8.578114e-004
12011, -2.443044e-001, 3.145759e-001, 7.713275e-004
12012, -2.446208e-001, 3.149898e-001, 1.339038e-003
12013, -2.441714e-001, 3.152720e-001, 2.290136e-003
12014, -2.454322e-001, 3.170426e-001, 3.073628e-003
12015, -2.457363e-001, 3.176944e-001, 3.338944e-003
12016, -2.460859e-001, 3.184933e-001, 3.596186e-003
12017, -2.464586e-001, 3.193745e-001, 3.800879e-003
12018, -2.468462e-001, 3.202924e-001, 3.934700e-003
12019, -2.472380e-001, 3.212202e-001, 3.995595e-003
12020, -2.476117e-001, 3.221333e-001, 3.985275e-003
12021, -2.479095e-001, 3.230308e-001, 3.896395e-003
12022, -2.481404e-001, 3.239054e-001, 3.713751e-003
12023, -2.482305e-001, 3.247417e-001, 3.393692e-003
12024, -2.483164e-001, 3.255597e-001, 2.917787e-003
12025, -2.485264e-001, 3.262320e-001, 2.446877e-003
12026, -2.484232e-001, 3.268024e-001, 1.544163e-003
12027, -2.434981e-001, 3.140993e-001, 1.086806e-003
12028, -2.426885e-001, 3.135201e-001, 1.064072e-003
12029, -2.418796e-001, 3.129503e-001, 1.067064e-003
12030, -2.410678e-001, 3.123785e-001, 1.070012e-003
12031, -2.402544e-001, 3.118049e-001, 1.071480e-003
12032, -2.394402e-001, 3.112308e-001, 1.072669e-003
12033, -2.386255e-001, 3.106563e-001, 1.073928e-003
12034, -2.378097e-001, 3.100812e-001, 1.075620e-003
12035, -2.369938e-001, 3.095057e-001, 1.076523e-003
12036, -2.361798e-001, 3.089308e-001, 1.074751e-003
12037, -2.353665e-001, 3.083562e-001, 1.073047e-003
12038, -2.345528e-001, 3.077817e-001, 1.072038e-003
12039, -2.337388e-001, 3.072071e-001, 1.071556e-003
12040, -2.329245e-001, 3.066324e-001, 1.071430e-003
12041, -2.321101e-001, 3.060577e-001, 1.071588e-003
12042, -2.312956e-001, 3.054832e-001, 1.072042e-003
12043, -2.304811e-001, 3.049085e-001, 1.072474e-003
12044, -2.296664e-001, 3.043337e-001, 1.072759e-003
12045, -2.288518e-001, 3.037589e-001, 1.072913e-003
12046, -2.280373e-001, 3.031841e-001, 1.072986e-003
12047, -2.272227e-001, 3.026093e-001, 1.073018e-003
12048, -2.264081e-001, 3.020345e-001, 1.073031e-003
12049, -2.255936e-001, 3.014597e-001, 1.073035e-003
12050, -2.247790e-001, 3.008849e-001, 1.073036e-003
12051, -2.239645e-001, 3.003101e-001, 1.073036e-003
12052, -2.231499e-001, 2.997353e-001, 1.073035e-003
12053, -2.223354e-001, 2.991604e-001, 1.073034e-003
12054, -2.215208e-001, 2.985856e-001, 1.073033e-003
12055, -2.207062e-001, 2.980108e-001, 1.073032e-003
12056, -2.198917e-001, 2.974360e-001, 1.073031e-003
12057, -2.190771e-001, 2.968612e-001, 1.073030e-003
12058, -2.182626e-001, 2.962864e-001, 1.073029e-003
12059, -2.174480e-001, 2.957116e-001, 1.073028e-003
12060, -2.166335e-001, 2.951367e-001, 1.073027e-003
12061, -2.158189e-001, 2.945619e-001, 1.073026e-003
12062, -2.150044e-001, 2.939871e-001, 1.073025e-003
12063, -2.141898e-001, 2.934123e-001, 1.073024e-003
12064, -2.133752e-001, 2.928375e-001, 1.073023e-003
12065, -2.125607e-001, 2.922627e-001, 1.073022e-003
12066, -2.117461e-001, 2.916879e-001, 1.073021e-003
12067, -2.109316e-001, 2.911131e-001, 1.073020e-003
12068, -2.101170e-001, 2.905382e-001, 1.073019e-003
12069, -2.093025e-001, 2.899634e-001, 1.073018e-003
12070, -2.084879e-001, 2.893886e-001, 1.073017e-003
12071, -2.076733e-001, 2.888138e-001, 1.073016e-003
12072, -2.068588e-001, 2.882390e-001, 1.073015e-003
12073, -2.060442e-001, 2.876642e-001, 1.073014e-003
12074, -2.052297e-001, 2.870894e-001, 1.073013e-003
12075, -2.044151e-001, 2.865146e-001, 1.073012e-003
12076, -2.036006e-001, 2.859397e-001, 1.073011e-003
12077, -2.027860e-001, 2.853649e-001, 1.073010e-003
12078, -2.019715e-001, 2.847901e-001, 1.073009e-003
12079, -2.011569e-001, 2.842153e-001, 1.073008e-003
12080, -2.003424e-001, 2.836405e-001, 1.073007e-003
12081, -1.995278e-001, 2.830657e-001, 1.073006e-003
12082, -1.987132e-001, 2.824909e-001, 1.073005e-003
12083, -1.978987e-001, 2.819160e-001, 1.073004e-003
12084, -1.970841e-001, 2.813412e-001, 1.073003e-003
12085, -1.962696e-001, 2.807664e-001, 1.073002e-003
12086, -1.954550e-001, 2.801916e-001, 1.073001e-003
12087, -1.946405e-001, 2.796168e-001, 1.073000e-003
12088, -1.938259e-001, 2.790420e-001, 1.072999e-003
12089, -1.930114e-001, 2.784672e-001, 1.072998e-003
12090, -1.921968e-001, 2.778924e-001, 1.072997e-003
12091, -1.913822e-001, 2.773175e-001, 1.072996e-003
12092, -1.905677e-001, 2.767427e-001, 1.072995e-003
12093, -1.897531e-001, 2.761679e-001, 1.072994e-003
12094, -1.889386e-001, 2.755931e-001, 1.072993e-003
12095, -1.881240e-001, 2.750183e-001, 1.072992e-003
12096, -1.873095e-001, 2.744435e-001, 1.072990e-003
12097, -1.864949e-001, 2.738687e-001, 1.072989e-003
12098, -1.856804e-001, 2.732939e-001, 1.072988e-003
12099, -1.848658e-001, 2.727190e-001, 1.072987e-003
12100, -1.840513e-001, 2.721442e-001, 1.072986e-003
12101, -1.832367e-001, 2.715694e-001, 1.072985e-003
12102, -1.824221e-001, 2.709946e-001, 1.072984e-003
12103, -1.816076e-001, 2.704198e-001, 1.072983e-003
12104, -1.807930e-001, 2.698450e-001, 1.072982e-003
12105, -1.799785e-001, 2.692702e-001, 1.072981e-003
12106, -1.791639e-001, 2.686954e-001, 1.072980e-003
12107, -1.783494e-001, 2.681205e-001, 1.072979e-003
12108, -1.775348e-001, 2.675457e-001, 1.072978e-003
12109, -1.767203e-001, 2.669709e-001, 1.072977e-003
12110, -1.759057e-001, 2.663961e-001, 1.072976e-003
12111, -1.750912e-001, 2.658213e-001, 1.072975e-003
12112, -1.742766e-001, 2.652465e-001, 1.072974e-003
12113, -1.734620e-001, 2.646717e-001, 1.072973e-003
12114, -1.726475e-001, 2.640969e-001, 1.072972e-003
12115, -1.718329e-001, 2.635221e-001, 1.072971e-003
12116, -1.710184e-001, 2.629472e-001, 1.072970e-003
12117, -1.702038e-001, 2.623724e-001, 1.072969e-003
12118, -1.693893e-001, 2.617976e-001, 1.072969e-003
12119, -1.685747e-001, 2.612228e-001, 1.072973e-003
12120, -1.677602e-001, 2.606480e-001, 1.072969e-003
12121, -1.669456e-001, 2.600732e-001, 1.072969e-003
12122, -1.661311e-001, 2.594984e-001, 1.072968e-003
12123, -1.653165e-001, 2.589236e-001, 1.072965e-003
12124, -1.645020e-001, 2.583487e-001, 1.072957e-003
12125, -1.636874e-001, 2.577739e-001, 1.072959e-003
12126, -1.628728e-001, 2.571991e-001, 1.072957e-003
12127, -1.620583e-001, 2.566243e-001, 1.072960e-003
12128, -1.612437e-001, 2.560495e-001, 1.072961e-003
12129, -1.604292e-001, 2.554747e-001, 1.072958e-003
12130, -1.596146e-001, 2.548999e-001, 1.072954e-003
12131, -1.588001e-001, 2.543251e-001, 1.072947e-003
12132, -1.579855e-001, 2.537503e-001, 1.072951e-003
12133, -1.571710e-001, 2.531754e-001, 1.072953e-003
12134, -1.563564e-001, 2.526006e-001, 1.072948e-003
12135, -1.555419e-001, 2.520258e-001, 1.072950e-003
12136, -1.547273e-001, 2.514510e-001, 1.072922e-003
12137, -1.539129e-001, 2.508761e-001, 1.072487e-003
12138, -1.530987e-001, 2.503013e-001, 1.071800e-003
12139, -1.522845e-001, 2.497266e-001, 1.071199e-003
12140, -1.514705e-001, 2.491518e-001, 1.070234e-003
12141, -1.506556e-001, 2.485762e-001, 1.068577e-003
12142, -1.498407e-001, 2.480000e-001, 1.065072e-003
12143, -1.490304e-001, 2.474257e-001, 1.057829e-003
12144, -1.482271e-001, 2.468574e-001, 1.053346e-003
12145, -1.474173e-001, 2.462911e-001, 1.068855e-003
12146, -1.465877e-001, 2.457039e-001, 1.063724e-003
12147, -1.457608e-001, 2.451178e-001, 1.055931e-003
12148, -1.449401e-001, 2.445382e-001, 1.054679e-003
12149, -1.441219e-001, 2.439635e-001, 1.062467e-003
12150, -1.433018e-001, 2.433837e-001, 1.059541e-003
12151, -1.424910e-001, 2.428089e-001, 1.051388e-003
12152, -1.416937e-001, 2.422441e-001, 1.045192e-003
12153, -1.409072e-001, 2.416930e-001, 1.056944e-003
12154, -1.401386e-001, 2.411379e-001, 1.017947e-003
12155, -1.395080e-001, 2.406788e-001, 9.730632e-004
12156, -1.390167e-001, 2.402742e-001, 7.598784e-004
12157, -1.473291e-001, 2.556883e-001, 9.950461e-004
12158, -1.463956e-001, 2.527290e-001, 3.467219e-003
12159, -1.457993e-001, 2.519043e-001, 3.637196e-003
12160, -1.452289e-001, 2.510470e-001, 3.785249e-003
12161, -1.446650e-001, 2.501903e-001, 3.893191e-003
12162, -1.441252e-001, 2.493338e-001, 3.964793e-003
12163, -1.435990e-001, 2.484699e-001, 3.997979e-003
12164, -1.431145e-001, 2.475976e-001, 3.988266e-003
12165, -1.425595e-001, 2.467248e-001, 3.938393e-003
12166, -1.420304e-001, 2.458745e-001, 3.848895e-003
12167, -1.415393e-001, 2.450531e-001, 3.717345e-003
12168, -1.412203e-001, 2.442169e-001, 3.477668e-003
12169, -1.406344e-001, 2.433555e-001, 3.242504e-003
12170, -1.401499e-001, 2.425645e-001, 2.942818e-003
12171, -1.396582e-001, 2.419980e-001, 2.766989e-003
12172, -1.397633e-001, 2.414150e-001, 2.065417e-003
12173, -1.392270e-001, 2.407648e-001, 1.641932e-003
12174, -1.388895e-001, 2.403742e-001, 1.330869e-003
12175, -1.511691e-001, 2.579517e-001, 1.919071e-003
12176, -1.503830e-001, 2.574097e-001, 1.900047e-003
12177, -1.496072e-001, 2.568981e-001, 1.844676e-003
12178, -1.487628e-001, 2.563652e-001, 1.742083e-003
12179, -1.519789e-001, 2.585228e-001, 1.919664e-003
12180, -1.527939e-001, 2.590981e-001, 1.919456e-003
12181, -1.536105e-001, 2.596747e-001, 1.918982e-003
12182, -1.544280e-001, 2.602518e-001, 1.918644e-003
12183, -1.552462e-001, 2.608291e-001, 1.918732e-003
12184, -1.560646e-001, 2.614065e-001, 1.918941e-003
12185, -1.568826e-001, 2.619838e-001, 1.918846e-003
12186, -1.577005e-001, 2.625611e-001, 1.918686e-003
12187, -1.585186e-001, 2.631384e-001, 1.918682e-003
12188, -1.593368e-001, 2.637158e-001, 1.918693e-003
12189, -1.601551e-001, 2.642932e-001, 1.918805e-003
12190, -1.609732e-001, 2.648705e-001, 1.918783e-003
12191, -1.617913e-001, 2.654478e-001, 1.918752e-003
12192, -1.626094e-001, 2.660252e-001, 1.918746e-003
12193, -1.634276e-001, 2.666025e-001, 1.918766e-003
12194, -1.642457e-001, 2.671799e-001, 1.918748e-003
12195, -1.650639e-001, 2.677572e-001, 1.918747e-003
12196, -1.658820e-001, 2.683345e-001, 1.918765e-003
12197, -1.667002e-001, 2.689119e-001, 1.918785e-003
12198, -1.675184e-001, 2.694892e-001, 1.918800e-003
12199, -1.683365e-001, 2.700666e-001, 1.918808e-003
12200, -1.691547e-001, 2.706439e-001, 1.918812e-003
12201, -1.699728e-001, 2.712213e-001, 1.918814e-003
12202, -1.707909e-001, 2.717986e-001, 1.918816e-003
12203, -1.716091e-001, 2.723760e-001, 1.918817e-003
12204, -1.724272e-001, 2.729533e-001, 1.918817e-003
12205, -1.732454e-001, 2.735306e-001, 1.918818e-003
12206, -1.740635e-001, 2.741080e-001, 1.918819e-003
12207, -1.748816e-001, 2.746853e-001, 1.918819e-003
12208, -1.756998e-001, 2.752627e-001, 1.918820e-003
12209, -1.765179e-001, 2.758400e-001, 1.918821e-003
12210, -1.773361e-001, 2.764173e-001, 1.918821e-003
12211, -1.781542e-001, 2.769947e-001, 1.918822e-003
12212, -1.789723e-001, 2.775720e-001, 1.918822e-003
12213, -1.797905e-001, 2.781494e-001, 1.918823e-003
12214, -1.806086e-001, 2.787267e-001, 1.918824e-003
12215, -1.814268e-001, 2.793041e-001, 1.918824e-003
12216, -1.822449e-001, 2.798814e-001, 1.918825e-003
12217, -1.830630e-001, 2.804587e-001, 1.918825e-003
12218, -1.838812e-001, 2.810361e-001, 1.918826e-003
12219, -1.846993e-001, 2.816134e-001, 1.918827e-003
12220, -1.855175e-001, 2.821908e-001, 1.918827e-003
12221, -1.863356e-001, 2.827681e-001, 1.918828e-003
12222, -1.871537e-001, 2.833454e-001, 1.918829e-003
12223, -1.879719e-001, 2.839228e-001, 1.918829e-003
12224, -1.887900e-001, 2.845001e-001, 1.918830e-003
12225, -1.896082e-001, 2.850775e-001, 1.918830e-003
12226, -1.904263e-001, 2.856548e-001, 1.918831e-003
12227, -1.912444e-001, 2.862322e-001, 1.918832e-003
12228, -1.920626e-001, 2.868095e-001, 1.918832e-003
12229, -1.928807e-001, 2.873868e-001, 1.918833e-003
12230, -1.936988e-001, 2.879642e-001, 1.918833e-003
12231, -1.945170e-001, 2.885415e-001, 1.918834e-003
12232, -1.953351e-001, 2.891189e-001, 1.918835e-003
12233, -1.961533e-001, 2.896962e-001, 1.918835e-003
12234, -1.969714e-001, 2.902735e-001, 1.918836e-003
12235, -1.977895e-001, 2.908509e-001, 1.918836e-003
12236, -1.986077e-001, 2.914282e-001, 1.918837e-003
12237, -1.994258e-001, 2.920056e-001, 1.918838e-003
12238, -2.002440e-001, 2.925829e-001, 1.918838e-003
12239, -2.010621e-001, 2.931602e-001, 1.918839e-003
12240, -2.018802e-001, 2.937376e-001, 1.918839e-003
12241, -2.026984e-001, 2.943149e-001, 1.918840e-003
12242, -2.035165e-001, 2.948923e-001, 1.918841e-003
12243, -2.043347e-001, 2.954696e-001, 1.918841e-003
12244, -2.051528e-001, 2.960470e-001, 1.918842e-003
12245, -2.059709e-001, 2.966243e-001, 1.918842e-003
12246, -2.067891e-001, 2.972016e-001, 1.918843e-003
12247, -2.076072e-001, 2.977790e-001, 1.918844e-003
12248, -2.084254e-001, 2.983563e-001, 1.918844e-003
12249, -2.092435e-001, 2.989337e-001, 1.918845e-003
12250, -2.100616e-001, 2.995110e-001, 1.918845e-003
12251, -2.108798e-001, 3.000883e-001, 1.918846e-003
12252, -2.116979e-001, 3.006657e-001, 1.918846e-003
12253, -2.125161e-001, 3.012430e-001, 1.918847e-003
12254, -2.133342e-001, 3.018204e-001, 1.918848e-003
12255, -2.141523e-001, 3.023977e-001, 1.918848e-003
12256, -2.149705e-001, 3.029750e-001, 1.918849e-003
12257, -2.157886e-001, 3.035524e-001, 1.918849e-003
12258, -2.166067e-001, 3.041297e-001, 1.918850e-003
12259, -2.174249e-001, 3.047071e-001, 1.918850e-003
12260, -2.182430e-001, 3.052844e-001, 1.918851e-003
12261, -2.190612e-001, 3.058618e-001, 1.918852e-003
12262, -2.198793e-001, 3.064391e-001, 1.918852e-003
12263, -2.206974e-001, 3.070164e-001, 1.918853e-003
12264, -2.215156e-001, 3.075938e-001, 1.918853e-003
12265, -2.223337e-001, 3.081711e-001, 1.918854e-003
12266, -2.231519e-001, 3.087485e-001, 1.918855e-003
12267, -2.239700e-001, 3.093258e-001, 1.918856e-003
12268, -2.247881e-001, 3.099031e-001, 1.918858e-003
12269, -2.256063e-001, 3.104805e-001, 1.918882e-003
12270, -2.264249e-001, 3.110582e-001, 1.918885e-003
12271, -2.272435e-001, 3.116362e-001, 1.918341e-003
12272, -2.280609e-001, 3.122139e-001, 1.916978e-003
12273, -2.288783e-001, 3.127915e-001, 1.915890e-003
12274, -2.296962e-001, 3.133690e-001, 1.915364e-003
12275, -2.305141e-001, 3.139464e-001, 1.914943e-003
12276, -2.313320e-001, 3.145240e-001, 1.914322e-003
12277, -2.321500e-001, 3.151013e-001, 1.914217e-003
12278, -2.329683e-001, 3.156782e-001, 1.915064e-003
12279, -2.337867e-001, 3.162549e-001, 1.916295e-003
12280, -2.346056e-001, 3.168320e-001, 1.917506e-003
12281, -2.354247e-001, 3.174097e-001, 1.917975e-003
12282, -2.362427e-001, 3.179879e-001, 1.916580e-003
12283, -2.370600e-001, 3.185656e-001, 1.915180e-003
12284, -2.378781e-001, 3.191428e-001, 1.915342e-003
12285, -2.386972e-001, 3.197191e-001, 1.917913e-003
12286, -2.395121e-001, 3.202944e-001, 1.917508e-003
12287, -2.403211e-001, 3.208699e-001, 1.910666e-003
12288, -2.411324e-001, 3.214429e-001, 1.909919e-003
12289, -2.419563e-001, 3.220176e-001, 1.919924e-003
12290, -2.428021e-001, 3.225985e-001, 1.943569e-003
12291, -2.436186e-001, 3.231734e-001, 1.945512e-003
12292, -2.444085e-001, 3.237179e-001, 1.964257e-003
12293, -2.452397e-001, 3.242473e-001, 2.044989e-003
12294, -2.461726e-001, 3.248615e-001, 2.104422e-003
12295, -2.472404e-001, 3.254956e-001, 2.254415e-003
12296, -2.479056e-001, 3.262666e-001, 1.842174e-003
12297, -2.432929e-001, 3.143598e-001, 1.902931e-003
12298, -2.439737e-001, 3.147682e-001, 1.789996e-003
12299, -2.441887e-001, 3.158839e-001, 2.866827e-003
12300, -2.444785e-001, 3.169569e-001, 3.416705e-003
12301, -2.417209e-001, 3.133402e-001, 2.032669e-003
12302, -2.425524e-001, 3.139004e-001, 1.995433e-003
12303, -2.448580e-001, 3.179109e-001, 3.700244e-003
12304, -2.451799e-001, 3.187948e-001, 3.877415e-003
12305, -2.455191e-001, 3.197145e-001, 3.977162e-003
12306, -2.459004e-001, 3.206602e-001, 3.998014e-003
12307, -2.463223e-001, 3.215980e-001, 3.946997e-003
12308, -2.467764e-001, 3.224529e-001, 3.849854e-003
12309, -2.470736e-001, 3.232566e-001, 3.678593e-003
12310, -2.473665e-001, 3.239878e-001, 3.464397e-003
12311, -2.472864e-001, 3.246437e-001, 3.055379e-003
12312, -2.409069e-001, 3.127729e-001, 2.042496e-003
12313, -2.400919e-001, 3.122015e-001, 2.047589e-003
12314, -2.392759e-001, 3.116295e-001, 2.052917e-003
12315, -2.384584e-001, 3.110568e-001, 2.058636e-003
12316, -2.376365e-001, 3.104814e-001, 2.064867e-003
12317, -2.368150e-001, 3.099030e-001, 2.066636e-003
12318, -2.360061e-001, 3.093249e-001, 2.056732e-003
12319, -2.351983e-001, 3.087497e-001, 2.049694e-003
12320, -2.343884e-001, 3.081755e-001, 2.045985e-003
12321, -2.335764e-001, 3.076014e-001, 2.044478e-003
12322, -2.327632e-001, 3.070276e-001, 2.044700e-003
12323, -2.319494e-001, 3.064546e-001, 2.046469e-003
12324, -2.311344e-001, 3.058818e-001, 2.049564e-003
12325, -2.303188e-001, 3.053081e-001, 2.052017e-003
12326, -2.295033e-001, 3.047336e-001, 2.053455e-003
12327, -2.286881e-001, 3.041589e-001, 2.054173e-003
12328, -2.278732e-001, 3.035840e-001, 2.054496e-003
12329, -2.270584e-001, 3.030092e-001, 2.054630e-003
12330, -2.262438e-001, 3.024343e-001, 2.054682e-003
12331, -2.254291e-001, 3.018594e-001, 2.054699e-003
12332, -2.246145e-001, 3.012846e-001, 2.054703e-003
12333, -2.237998e-001, 3.007097e-001, 2.054702e-003
12334, -2.229852e-001, 3.001348e-001, 2.054699e-003
12335, -2.221706e-001, 2.995600e-001, 2.054695e-003
12336, -2.213559e-001, 2.989851e-001, 2.054691e-003
12337, -2.205413e-001, 2.984102e-001, 2.054687e-003
12338, -2.197267e-001, 2.978354e-001, 2.054683e-003
12339, -2.189120e-001, 2.972605e-001, 2.054679e-003
12340, -2.180974e-001, 2.966856e-001, 2.054675e-003
12341, -2.172828e-001, 2.961108e-001, 2.054671e-003
12342, -2.164682e-001, 2.955359e-001, 2.054666e-003
12343, -2.156535e-001, 2.949610e-001, 2.054662e-003
12344, -2.148389e-001, 2.943862e-001, 2.054658e-003
12345, -2.140243e-001, 2.938113e-001, 2.054654e-003
12346, -2.132096e-001, 2.932364e-001, 2.054650e-003
12347, -2.123950e-001, 2.926616e-001, 2.054646e-003
12348, -2.115804e-001, 2.920867e-001, 2.054641e-003
12349, -2.107658e-001, 2.915118e-001, 2.054637e-003
12350, -2.099511e-001, 2.909369e-001, 2.054633e-003
12351, -2.091365e-001, 2.903621e-001, 2.054629e-003
12352, -2.083219e-001, 2.897872e-001, 2.054624e-003
12353, -2.075072e-001, 2.892123e-001, 2.054620e-003
12354, -2.066926e-001, 2.886375e-001, 2.054616e-003
12355, -2.058780e-001, 2.880626e-001, 2.054612e-003
12356, -2.050634e-001, 2.874877e-001, 2.054607e-003
12357, -2.042487e-001, 2.869129e-001, 2.054603e-003
12358, -2.034341e-001, 2.863380e-001, 2.054599e-003
12359, -2.026195e-001, 2.857631e-001, 2.054594e-003
12360, -2.018048e-001, 2.851883e-001, 2.054590e-003
12361, -2.009902e-001, 2.846134e-001, 2.054586e-003
12362, -2.001756e-001, 2.840385e-001, 2.054581e-003
12363, -1.993610e-001, 2.834637e-001, 2.054577e-003
12364, -1.985463e-001, 2.828888e-001, 2.054573e-003
12365, -1.977317e-001, 2.823139e-001, 2.054568e-003
12366, -1.969171e-001, 2.817391e-001, 2.054564e-003
12367, -1.961025e-001, 2.811642e-001, 2.054560e-003
12368, -1.952878e-001, 2.805893e-001, 2.054555e-003
12369, -1.944732e-001, 2.800145e-001, 2.054551e-003
12370, -1.936586e-001, 2.794396e-001, 2.054546e-003
12371, -1.928439e-001, 2.788648e-001, 2.054542e-003
12372, -1.920293e-001, 2.782899e-001, 2.054538e-003
12373, -1.912147e-001, 2.777150e-001, 2.054533e-003
12374, -1.904001e-001, 2.771402e-001, 2.054529e-003
12375, -1.895854e-001, 2.765653e-001, 2.054525e-003
12376, -1.887708e-001, 2.759904e-001, 2.054520e-003
12377, -1.879562e-001, 2.754156e-001, 2.054516e-003
12378, -1.871416e-001, 2.748407e-001, 2.054511e-003
12379, -1.863269e-001, 2.742658e-001, 2.054507e-003
12380, -1.855123e-001, 2.736910e-001, 2.054503e-003
12381, -1.846977e-001, 2.731161e-001, 2.054498e-003
12382, -1.838831e-001, 2.725412e-001, 2.054494e-003
12383, -1.830684e-001, 2.719664e-001, 2.054489e-003
12384, -1.822538e-001, 2.713915e-001, 2.054485e-003
12385, -1.814392e-001, 2.708166e-001, 2.054481e-003
12386, -1.806246e-001, 2.702418e-001, 2.054476e-003
12387, -1.798100e-001, 2.696669e-001, 2.054472e-003
12388, -1.789953e-001, 2.690921e-001, 2.054467e-003
12389, -1.781807e-001, 2.685172e-001, 2.054463e-003
12390, -1.773661e-001, 2.679423e-001, 2.054459e-003
12391, -1.765515e-001, 2.673675e-001, 2.054454e-003
12392, -1.757368e-001, 2.667926e-001, 2.054450e-003
12393, -1.749222e-001, 2.662177e-001, 2.054446e-003
12394, -1.741076e-001, 2.656429e-001, 2.054441e-003
12395, -1.732930e-001, 2.650680e-001, 2.054437e-003
12396, -1.724783e-001, 2.644931e-001, 2.054433e-003
12397, -1.716637e-001, 2.639183e-001, 2.054429e-003
12398, -1.708491e-001, 2.633434e-001, 2.054426e-003
12399, -1.700345e-001, 2.627686e-001, 2.054427e-003
12400, -1.692198e-001, 2.621937e-001, 2.054448e-003
12401, -1.684052e-001, 2.616188e-001, 2.054454e-003
12402, -1.675906e-001, 2.610440e-001, 2.054439e-003
12403, -1.667759e-001, 2.604691e-001, 2.054443e-003
12404, -1.659613e-001, 2.598942e-001, 2.054430e-003
12405, -1.651468e-001, 2.593194e-001, 2.054383e-003
12406, -1.643322e-001, 2.587445e-001, 2.054351e-003
12407, -1.635176e-001, 2.581697e-001, 2.054354e-003
12408, -1.627029e-001, 2.575948e-001, 2.054362e-003
12409, -1.618883e-001, 2.570199e-001, 2.054388e-003
12410, -1.610736e-001, 2.564451e-001, 2.054388e-003
12411, -1.602590e-001, 2.558702e-001, 2.054364e-003
12412, -1.594445e-001, 2.552954e-001, 2.054320e-003
12413, -1.586299e-001, 2.547205e-001, 2.054299e-003
12414, -1.578153e-001, 2.541457e-001, 2.054328e-003
12415, -1.570006e-001, 2.535708e-001, 2.054324e-003
12416, -1.561860e-001, 2.529959e-001, 2.054311e-003
12417, -1.553713e-001, 2.524210e-001, 2.054328e-003
12418, -1.545570e-001, 2.518458e-001, 2.053520e-003
12419, -1.537436e-001, 2.512702e-001, 2.051291e-003
12420, -1.529312e-001, 2.506945e-001, 2.047981e-003
12421, -1.521193e-001, 2.501195e-001, 2.045159e-003
12422, -1.513065e-001, 2.495444e-001, 2.043109e-003
12423, -1.504903e-001, 2.489674e-001, 2.041672e-003
12424, -1.496741e-001, 2.483868e-001, 2.035301e-003
12425, -1.488712e-001, 2.478040e-001, 2.012778e-003
12426, -1.480987e-001, 2.472350e-001, 1.978808e-003
12427, -1.472999e-001, 2.467186e-001, 2.045271e-003
12428, -1.464354e-001, 2.460927e-001, 2.023396e-003
12429, -1.455926e-001, 2.454836e-001, 2.003173e-003
12430, -1.447678e-001, 2.448987e-001, 1.999157e-003
12431, -1.439467e-001, 2.443414e-001, 2.030124e-003
12432, -1.431133e-001, 2.437438e-001, 2.016972e-003
12433, -1.423030e-001, 2.431594e-001, 1.999158e-003
12434, -1.415237e-001, 2.425979e-001, 1.982811e-003
12435, -1.407274e-001, 2.421250e-001, 2.105056e-003
12436, -1.471710e-001, 2.551201e-001, 1.934377e-003
12437, -1.477094e-001, 2.550601e-001, 2.475839e-003
12438, -1.473731e-001, 2.544818e-001, 2.793281e-003
12439, -1.478799e-001, 2.558622e-001, 1.522911e-003
12440, -1.470013e-001, 2.534207e-001, 3.333678e-003
12441, -2.434191e-001, 3.153178e-001, 2.848346e-003
12442, -1.461187e-001, 2.505715e-001, 3.980797e-003
12443, -1.455137e-001, 2.497421e-001, 3.999509e-003
12444, -1.449811e-001, 2.489158e-001, 3.988320e-003
12445, -1.444339e-001, 2.480737e-001, 3.942120e-003
12446, -1.440900e-001, 2.472036e-001, 3.818720e-003
12447, -1.434146e-001, 2.463074e-001, 3.694409e-003
12448, -1.428467e-001, 2.454576e-001, 3.519781e-003
12449, -1.422663e-001, 2.447874e-001, 3.396224e-003
12450, -1.419385e-001, 2.436264e-001, 2.783386e-003
12451, -1.412929e-001, 2.430331e-001, 2.662293e-003
12452, -1.515329e-001, 2.574930e-001, 2.728439e-003
12453, -1.507618e-001, 2.569893e-001, 2.692623e-003
12454, -1.481319e-001, 2.555513e-001, 2.261346e-003
12455, -1.523322e-001, 2.580514e-001, 2.733374e-003
12456, -1.547725e-001, 2.597754e-001, 2.731698e-003
12457, -1.539572e-001, 2.591984e-001, 2.733152e-003
12458, -1.555922e-001, 2.603528e-001, 2.732603e-003
12459, -1.564116e-001, 2.609301e-001, 2.733421e-003
12460, -1.572287e-001, 2.615073e-001, 2.732871e-003
12461, -1.580454e-001, 2.620845e-001, 2.732135e-003
12462, -1.588637e-001, 2.626618e-001, 2.732242e-003
12463, -1.596821e-001, 2.632392e-001, 2.732421e-003
12464, -1.605007e-001, 2.638165e-001, 2.732757e-003
12465, -1.613185e-001, 2.643937e-001, 2.732574e-003
12466, -1.621364e-001, 2.649710e-001, 2.732482e-003
12467, -1.629544e-001, 2.655483e-001, 2.732484e-003
12468, -1.637725e-001, 2.661256e-001, 2.732500e-003
12469, -1.645905e-001, 2.667029e-001, 2.732445e-003
12470, -1.654086e-001, 2.672802e-001, 2.732463e-003
12471, -1.662268e-001, 2.678575e-001, 2.732531e-003
12472, -1.670450e-001, 2.684347e-001, 2.732598e-003
12473, -1.678631e-001, 2.690120e-001, 2.732645e-003
12474, -1.686812e-001, 2.695893e-001, 2.732673e-003
12475, -1.694993e-001, 2.701666e-001, 2.732688e-003
12476, -1.703174e-001, 2.707439e-001, 2.732696e-003
12477, -1.711354e-001, 2.713212e-001, 2.732701e-003
12478, -1.719535e-001, 2.718985e-001, 2.732704e-003
12479, -1.727715e-001, 2.724757e-001, 2.732707e-003
12480, -1.735896e-001, 2.730530e-001, 2.732710e-003
12481, -1.744077e-001, 2.736303e-001, 2.732712e-003
12482, -1.752257e-001, 2.742076e-001, 2.732715e-003
12483, -1.760438e-001, 2.747849e-001, 2.732717e-003
12484, -1.768618e-001, 2.753622e-001, 2.732719e-003
12485, -1.776799e-001, 2.759394e-001, 2.732722e-003
12486, -1.784980e-001, 2.765167e-001, 2.732724e-003
12487, -1.793160e-001, 2.770940e-001, 2.732727e-003
12488, -1.801341e-001, 2.776713e-001, 2.732729e-003
12489, -1.809522e-001, 2.782486e-001, 2.732731e-003
12490, -1.817702e-001, 2.788259e-001, 2.732734e-003
12491, -1.825883e-001, 2.794032e-001, 2.732736e-003
12492, -1.834063e-001, 2.799804e-001, 2.732739e-003
12493, -1.842244e-001, 2.805577e-001, 2.732741e-003
12494, -1.850425e-001, 2.811350e-001, 2.732743e-003
12495, -1.858605e-001, 2.817123e-001, 2.732746e-003
12496, -1.866786e-001, 2.822896e-001, 2.732748e-003
12497, -1.874966e-001, 2.828669e-001, 2.732750e-003
12498, -1.883147e-001, 2.834441e-001, 2.732753e-003
12499, -1.891328e-001, 2.840214e-001, 2.732755e-003
12500, -1.899508e-001, 2.845987e-001, 2.732757e-003
12501, -1.907689e-001, 2.851760e-001, 2.732760e-003
12502, -1.915869e-001, 2.857533e-001, 2.732762e-003
12503, -1.924050e-001, 2.863305e-001, 2.732764e-003
12504, -1.932231e-001, 2.869078e-001, 2.732767e-003
12505, -1.940411e-001, 2.874851e-001, 2.732769e-003
12506, -1.948592e-001, 2.880624e-001, 2.732771e-003
12507, -1.956772e-001, 2.886397e-001, 2.732774e-003
12508, -1.964953e-001, 2.892170e-001, 2.732776e-003
12509, -1.973134e-001, 2.897942e-001, 2.732778e-003
12510, -1.981314e-001, 2.903715e-001, 2.732781e-003
12511, -1.989495e-001, 2.909488e-001, 2.732783e-003
12512, -1.997675e-001, 2.915261e-001, 2.732785e-003
12513, -2.005856e-001, 2.921034e-001, 2.732787e-003
12514, -2.014037e-001, 2.926807e-001, 2.732790e-003
12515, -2.022217e-001, 2.932579e-001, 2.732792e-003
12516, -2.030398e-001, 2.938352e-001, 2.732794e-003
12517, -2.038578e-001, 2.944125e-001, 2.732797e-003
12518, -2.046759e-001, 2.949898e-001, 2.732799e-003
12519, -2.054940e-001, 2.955671e-001, 2.732801e-003
12520, -2.063120e-001, 2.961444e-001, 2.732803e-003
12521, -2.071301e-001, 2.967216e-001, 2.732805e-003
12522, -2.079481e-001, 2.972989e-001, 2.732808e-003
12523, -2.087662e-001, 2.978762e-001, 2.732810e-003
12524, -2.095842e-001, 2.984535e-001, 2.732812e-003
12525, -2.104023e-001, 2.990308e-001, 2.732814e-003
12526, -2.112204e-001, 2.996080e-001, 2.732817e-003
12527, -2.120384e-001, 3.001853e-001, 2.732819e-003
12528, -2.128565e-001, 3.007626e-001, 2.732821e-003
12529, -2.136745e-001, 3.013399e-001, 2.732823e-003
12530, -2.144926e-001, 3.019172e-001, 2.732825e-003
12531, -2.153107e-001, 3.024945e-001, 2.732827e-003
12532, -2.161287e-001, 3.030717e-001, 2.732830e-003
12533, -2.169468e-001, 3.036490e-001, 2.732832e-003
12534, -2.177648e-001, 3.042263e-001, 2.732834e-003
12535, -2.185829e-001, 3.048036e-001, 2.732836e-003
12536, -2.194009e-001, 3.053809e-001, 2.732838e-003
12537, -2.202190e-001, 3.059582e-001, 2.732840e-003
12538, -2.210371e-001, 3.065354e-001, 2.732842e-003
12539, -2.218551e-001, 3.071127e-001, 2.732845e-003
12540, -2.226732e-001, 3.076900e-001, 2.732847e-003
12541, -2.234912e-001, 3.082673e-001, 2.732851e-003
12542, -2.243093e-001, 3.088446e-001, 2.732860e-003
12543, -2.251274e-001, 3.094218e-001, 2.732909e-003
12544, -2.259468e-001, 3.100000e-001, 2.732971e-003
12545, -2.267671e-001, 3.105799e-001, 2.732012e-003
12546, -2.275852e-001, 3.111617e-001, 2.728100e-003
12547, -2.283983e-001, 3.117432e-001, 2.721326e-003
12548, -2.292122e-001, 3.123231e-001, 2.716463e-003
12549, -2.300276e-001, 3.129016e-001, 2.713707e-003
12550, -2.308436e-001, 3.134801e-001, 2.711350e-003
12551, -2.316601e-001, 3.140579e-001, 2.709956e-003
12552, -2.324782e-001, 3.146331e-001, 2.711752e-003
12553, -2.332981e-001, 3.152062e-001, 2.716669e-003
12554, -2.341201e-001, 3.157796e-001, 2.722529e-003
12555, -2.349437e-001, 3.163554e-001, 2.727265e-003
12556, -2.357660e-001, 3.169361e-001, 2.726907e-003
12557, -2.365814e-001, 3.175206e-001, 2.718880e-003
12558, -2.373943e-001, 3.180997e-001, 2.714111e-003
12559, -2.382110e-001, 3.186733e-001, 2.716472e-003
12560, -2.390269e-001, 3.192441e-001, 2.720820e-003
12561, -2.398324e-001, 3.198226e-001, 2.711980e-003
12562, -2.406218e-001, 3.203980e-001, 2.695696e-003
12563, -2.414311e-001, 3.209553e-001, 2.707905e-003
12564, -2.422673e-001, 3.215162e-001, 2.733618e-003
12565, -2.431853e-001, 3.220929e-001, 2.794419e-003
12566, -2.439671e-001, 3.226982e-001, 2.748828e-003
12567, -2.446607e-001, 3.232028e-001, 2.735691e-003
12568, -2.454930e-001, 3.235321e-001, 2.944513e-003
12569, -2.465185e-001, 3.242654e-001, 2.937219e-003
12570, -2.405963e-001, 3.133279e-001, 2.850046e-003
12571, -2.414493e-001, 3.139152e-001, 2.838240e-003
12572, -2.431463e-001, 3.161680e-001, 3.488903e-003
12573, -2.433501e-001, 3.174402e-001, 3.863914e-003
12574, -2.397723e-001, 3.127586e-001, 2.859812e-003
12575, -2.433296e-001, 3.148300e-001, 2.458522e-003
12576, -2.440101e-001, 3.182946e-001, 3.935230e-003
12577, -2.442340e-001, 3.191133e-001, 3.996080e-003
12578, -2.445215e-001, 3.200551e-001, 3.977181e-003
12579, -2.449133e-001, 3.210378e-001, 3.872040e-003
12580, -2.453689e-001, 3.220374e-001, 3.684231e-003
12581, -2.460862e-001, 3.227813e-001, 3.595923e-003
12582, -2.462831e-001, 3.234849e-001, 3.331890e-003
12583, -1.472620e-001, 2.522916e-001, 3.834790e-003
12584, -1.466827e-001, 2.514317e-001, 3.925365e-003
12585, -2.381157e-001, 3.116299e-001, 2.891669e-003
12586, -2.389455e-001, 3.121945e-001, 2.875221e-003
12587, -2.372718e-001, 3.110534e-001, 2.906457e-003
12588, -2.364275e-001, 3.104606e-001, 2.908756e-003
12589, -2.356497e-001, 3.098624e-001, 2.870211e-003
12590, -2.348628e-001, 3.092840e-001, 2.851773e-003
12591, -2.340653e-001, 3.087112e-001, 2.843651e-003
12592, -2.332602e-001, 3.081404e-001, 2.841491e-003
12593, -2.324506e-001, 3.075728e-001, 2.844498e-003
12594, -2.316372e-001, 3.070089e-001, 2.852615e-003
12595, -2.308168e-001, 3.064456e-001, 2.865148e-003
12596, -2.299944e-001, 3.058761e-001, 2.873743e-003
12597, -2.291738e-001, 3.053028e-001, 2.878281e-003
12598, -2.283556e-001, 3.047281e-001, 2.880417e-003
12599, -2.275391e-001, 3.041531e-001, 2.881353e-003
12600, -2.267235e-001, 3.035780e-001, 2.881739e-003
12601, -2.259083e-001, 3.030029e-001, 2.881890e-003
12602, -2.250933e-001, 3.024279e-001, 2.881943e-003
12603, -2.242783e-001, 3.018528e-001, 2.881957e-003
12604, -2.234634e-001, 3.012777e-001, 2.881957e-003
12605, -2.226485e-001, 3.007027e-001, 2.881951e-003
12606, -2.218336e-001, 3.001276e-001, 2.881943e-003
12607, -2.210187e-001, 2.995525e-001, 2.881935e-003
12608, -2.202038e-001, 2.989775e-001, 2.881926e-003
12609, -2.193889e-001, 2.984024e-001, 2.881917e-003
12610, -2.185740e-001, 2.978273e-001, 2.881907e-003
12611, -2.177591e-001, 2.972523e-001, 2.881898e-003
12612, -2.169442e-001, 2.966772e-001, 2.881889e-003
12613, -2.161293e-001, 2.961021e-001, 2.881880e-003
12614, -2.153144e-001, 2.955271e-001, 2.881871e-003
12615, -2.144995e-001, 2.949520e-001, 2.881861e-003
12616, -2.136846e-001, 2.943770e-001, 2.881852e-003
12617, -2.128697e-001, 2.938019e-001, 2.881843e-003
12618, -2.120548e-001, 2.932268e-001, 2.881833e-003
12619, -2.112400e-001, 2.926518e-001, 2.881824e-003
12620, -2.104251e-001, 2.920767e-001, 2.881814e-003
12621, -2.096102e-001, 2.915016e-001, 2.881805e-003
12622, -2.087953e-001, 2.909266e-001, 2.881795e-003
12623, -2.079804e-001, 2.903515e-001, 2.881786e-003
12624, -2.071655e-001, 2.897764e-001, 2.881777e-003
12625, -2.063506e-001, 2.892014e-001, 2.881767e-003
12626, -2.055357e-001, 2.886263e-001, 2.881757e-003
12627, -2.047208e-001, 2.880513e-001, 2.881748e-003
12628, -2.039059e-001, 2.874762e-001, 2.881738e-003
12629, -2.030910e-001, 2.869011e-001, 2.881729e-003
12630, -2.022761e-001, 2.863261e-001, 2.881719e-003
12631, -2.014612e-001, 2.857510e-001, 2.881709e-003
12632, -2.006464e-001, 2.851759e-001, 2.881699e-003
12633, -1.998315e-001, 2.846009e-001, 2.881690e-003
12634, -1.990166e-001, 2.840258e-001, 2.881680e-003
12635, -1.982017e-001, 2.834508e-001, 2.881670e-003
12636, -1.973868e-001, 2.828757e-001, 2.881660e-003
12637, -1.965719e-001, 2.823006e-001, 2.881651e-003
12638, -1.957570e-001, 2.817256e-001, 2.881641e-003
12639, -1.949421e-001, 2.811505e-001, 2.881631e-003
12640, -1.941273e-001, 2.805755e-001, 2.881621e-003
12641, -1.933124e-001, 2.800004e-001, 2.881611e-003
12642, -1.924975e-001, 2.794254e-001, 2.881601e-003
12643, -1.916826e-001, 2.788503e-001, 2.881592e-003
12644, -1.908677e-001, 2.782752e-001, 2.881582e-003
12645, -1.900528e-001, 2.777002e-001, 2.881572e-003
12646, -1.892379e-001, 2.771251e-001, 2.881562e-003
12647, -1.884231e-001, 2.765501e-001, 2.881552e-003
12648, -1.876082e-001, 2.759750e-001, 2.881542e-003
12649, -1.867933e-001, 2.753999e-001, 2.881532e-003
12650, -1.859784e-001, 2.748249e-001, 2.881523e-003
12651, -1.851635e-001, 2.742498e-001, 2.881513e-003
12652, -1.843486e-001, 2.736748e-001, 2.881503e-003
12653, -1.835338e-001, 2.730997e-001, 2.881493e-003
12654, -1.827189e-001, 2.725247e-001, 2.881483e-003
12655, -1.819040e-001, 2.719496e-001, 2.881473e-003
12656, -1.810891e-001, 2.713746e-001, 2.881463e-003
12657, -1.802742e-001, 2.707995e-001, 2.881453e-003
12658, -1.794593e-001, 2.702244e-001, 2.881443e-003
12659, -1.786445e-001, 2.696494e-001, 2.881434e-003
12660, -1.778296e-001, 2.690743e-001, 2.881424e-003
12661, -1.770147e-001, 2.684993e-001, 2.881414e-003
12662, -1.761998e-001, 2.679242e-001, 2.881404e-003
12663, -1.753850e-001, 2.673492e-001, 2.881394e-003
12664, -1.745701e-001, 2.667741e-001, 2.881384e-003
12665, -1.737552e-001, 2.661991e-001, 2.881375e-003
12666, -1.729403e-001, 2.656240e-001, 2.881365e-003
12667, -1.721254e-001, 2.650490e-001, 2.881357e-003
12668, -1.713106e-001, 2.644739e-001, 2.881351e-003
12669, -1.704957e-001, 2.638989e-001, 2.881356e-003
12670, -1.696807e-001, 2.633238e-001, 2.881408e-003
12671, -1.688657e-001, 2.627488e-001, 2.881471e-003
12672, -1.680508e-001, 2.621737e-001, 2.881475e-003
12673, -1.672359e-001, 2.615987e-001, 2.881442e-003
12674, -1.664210e-001, 2.610236e-001, 2.881436e-003
12675, -1.656063e-001, 2.604486e-001, 2.881323e-003
12676, -1.647918e-001, 2.598735e-001, 2.881158e-003
12677, -1.639770e-001, 2.592985e-001, 2.881064e-003
12678, -1.631621e-001, 2.587234e-001, 2.881085e-003
12679, -1.623471e-001, 2.581484e-001, 2.881154e-003
12680, -1.615320e-001, 2.575733e-001, 2.881242e-003
12681, -1.607172e-001, 2.569983e-001, 2.881220e-003
12682, -1.599026e-001, 2.564233e-001, 2.881084e-003
12683, -1.590880e-001, 2.558483e-001, 2.880946e-003
12684, -1.582732e-001, 2.552732e-001, 2.880936e-003
12685, -1.574582e-001, 2.546982e-001, 2.880990e-003
12686, -1.566434e-001, 2.541231e-001, 2.880965e-003
12687, -1.558284e-001, 2.535481e-001, 2.880980e-003
12688, -1.550141e-001, 2.529722e-001, 2.880023e-003
12689, -1.542011e-001, 2.523944e-001, 2.876835e-003
12690, -1.533902e-001, 2.518144e-001, 2.870682e-003
12691, -1.525850e-001, 2.512334e-001, 2.860464e-003
12692, -1.517811e-001, 2.506569e-001, 2.853115e-003
12693, -1.509711e-001, 2.500835e-001, 2.851696e-003
12694, -1.501485e-001, 2.495082e-001, 2.855816e-003
12695, -1.493232e-001, 2.489204e-001, 2.851520e-003
12696, -1.485150e-001, 2.483038e-001, 2.813843e-003
12697, -1.478654e-001, 2.476713e-001, 2.662358e-003
12698, -1.470969e-001, 2.474349e-001, 2.918578e-003
12699, -1.461268e-001, 2.466195e-001, 2.814603e-003
12700, -1.452691e-001, 2.459688e-001, 2.776647e-003
12701, -1.444561e-001, 2.453750e-001, 2.759489e-003
12702, -1.436314e-001, 2.449249e-001, 2.868339e-003
12703, -1.427621e-001, 2.442352e-001, 2.806408e-003
12704, -1.499907e-001, 2.565214e-001, 2.622534e-003
12705, -1.491314e-001, 2.559654e-001, 2.574316e-003
12706, -1.482164e-001, 2.550477e-001, 2.817556e-003
12707, -1.481425e-001, 2.545740e-001, 3.126664e-003
12708, -1.531446e-001, 2.586233e-001, 2.734622e-003
12709, -1.477469e-001, 2.531029e-001, 3.699530e-003
12710, -2.424539e-001, 3.146193e-001, 2.834293e-003
12711, -2.429007e-001, 3.154450e-001, 3.195839e-003
12712, -1.474946e-001, 2.539051e-001, 3.257138e-003
12713, -1.470833e-001, 2.556558e-001, 2.908718e-004
12714, -1.528107e-001, 2.574290e-001, 3.381967e-003
12715, -1.520168e-001, 2.568957e-001, 3.367972e-003
12716, -1.458365e-001, 2.485224e-001, 3.839992e-003
12717, -1.451827e-001, 2.477861e-001, 3.767211e-003
12718, -1.448146e-001, 2.465376e-001, 3.371457e-003
12719, -1.441493e-001, 2.459194e-001, 3.290726e-003
12720, -1.512360e-001, 2.564325e-001, 3.320906e-003
12721, -1.504724e-001, 2.560511e-001, 3.230832e-003
12722, -1.462919e-001, 2.492723e-001, 3.925199e-003
12723, -1.489295e-001, 2.553143e-001, 2.999847e-003
12724, -1.475834e-001, 2.508999e-001, 3.995734e-003
12725, -1.470748e-001, 2.500060e-001, 3.951370e-003
12726, -1.497878e-001, 2.557011e-001, 3.148532e-003
12727, -1.552461e-001, 2.591474e-001, 3.382049e-003
12728, -1.544337e-001, 2.585705e-001, 3.383947e-003
12729, -1.560666e-001, 2.597243e-001, 3.383145e-003
12730, -1.585154e-001, 2.614559e-001, 3.381356e-003
12731, -1.577022e-001, 2.608784e-001, 3.383252e-003
12732, -1.593351e-001, 2.620328e-001, 3.382127e-003
12733, -1.601536e-001, 2.626099e-001, 3.382391e-003
12734, -1.609729e-001, 2.631868e-001, 3.383034e-003
12735, -1.617895e-001, 2.637641e-001, 3.382469e-003
12736, -1.626071e-001, 2.643413e-001, 3.382390e-003
12737, -1.634249e-001, 2.649184e-001, 3.382368e-003
12738, -1.642427e-001, 2.654955e-001, 3.382379e-003
12739, -1.650603e-001, 2.660727e-001, 3.382280e-003
12740, -1.658783e-001, 2.666498e-001, 3.382331e-003
12741, -1.666964e-001, 2.672269e-001, 3.382450e-003
12742, -1.675145e-001, 2.678039e-001, 3.382560e-003
12743, -1.683324e-001, 2.683810e-001, 3.382636e-003
12744, -1.691504e-001, 2.689581e-001, 3.382681e-003
12745, -1.699682e-001, 2.695352e-001, 3.382705e-003
12746, -1.707861e-001, 2.701123e-001, 3.382719e-003
12747, -1.716039e-001, 2.706895e-001, 3.382727e-003
12748, -1.724217e-001, 2.712666e-001, 3.382732e-003
12749, -1.732395e-001, 2.718437e-001, 3.382737e-003
12750, -1.740574e-001, 2.724208e-001, 3.382741e-003
12751, -1.748752e-001, 2.729979e-001, 3.382745e-003
12752, -1.756930e-001, 2.735750e-001, 3.382748e-003
12753, -1.765108e-001, 2.741521e-001, 3.382752e-003
12754, -1.773286e-001, 2.747292e-001, 3.382756e-003
12755, -1.781465e-001, 2.753063e-001, 3.382759e-003
12756, -1.789643e-001, 2.758834e-001, 3.382763e-003
12757, -1.797821e-001, 2.764605e-001, 3.382766e-003
12758, -1.805999e-001, 2.770376e-001, 3.382770e-003
12759, -1.814177e-001, 2.776147e-001, 3.382774e-003
12760, -1.822355e-001, 2.781918e-001, 3.382777e-003
12761, -1.830534e-001, 2.787690e-001, 3.382781e-003
12762, -1.838712e-001, 2.793461e-001, 3.382784e-003
12763, -1.846890e-001, 2.799232e-001, 3.382788e-003
12764, -1.855068e-001, 2.805003e-001, 3.382791e-003
12765, -1.863246e-001, 2.810774e-001, 3.382795e-003
12766, -1.871424e-001, 2.816545e-001, 3.382798e-003
12767, -1.879603e-001, 2.822316e-001, 3.382802e-003
12768, -1.887781e-001, 2.828087e-001, 3.382805e-003
12769, -1.895959e-001, 2.833858e-001, 3.382808e-003
12770, -1.904137e-001, 2.839629e-001, 3.382812e-003
12771, -1.912315e-001, 2.845400e-001, 3.382815e-003
12772, -1.920493e-001, 2.851171e-001, 3.382819e-003
12773, -1.928671e-001, 2.856942e-001, 3.382822e-003
12774, -1.936850e-001, 2.862713e-001, 3.382825e-003
12775, -1.945028e-001, 2.868484e-001, 3.382829e-003
12776, -1.953206e-001, 2.874256e-001, 3.382832e-003
12777, -1.961384e-001, 2.880027e-001, 3.382836e-003
12778, -1.969562e-001, 2.885798e-001, 3.382839e-003
12779, -1.977740e-001, 2.891569e-001, 3.382842e-003
12780, -1.985918e-001, 2.897340e-001, 3.382846e-003
12781, -1.994097e-001, 2.903111e-001, 3.382849e-003
12782, -2.002275e-001, 2.908882e-001, 3.382852e-003
12783, -2.010453e-001, 2.914653e-001, 3.382856e-003
12784, -2.018631e-001, 2.920424e-001, 3.382859e-003
12785, -2.026809e-001, 2.926195e-001, 3.382862e-003
12786, -2.034987e-001, 2.931966e-001, 3.382865e-003
12787, -2.043165e-001, 2.937737e-001, 3.382869e-003
12788, -2.051344e-001, 2.943508e-001, 3.382872e-003
12789, -2.059522e-001, 2.949279e-001, 3.382875e-003
12790, -2.067700e-001, 2.955050e-001, 3.382878e-003
12791, -2.075878e-001, 2.960821e-001, 3.382881e-003
12792, -2.084056e-001, 2.966592e-001, 3.382885e-003
12793, -2.092234e-001, 2.972363e-001, 3.382888e-003
12794, -2.100412e-001, 2.978134e-001, 3.382891e-003
12795, -2.108590e-001, 2.983906e-001, 3.382894e-003
12796, -2.116769e-001, 2.989677e-001, 3.382897e-003
12797, -2.124947e-001, 2.995448e-001, 3.382901e-003
12798, -2.133125e-001, 3.001219e-001, 3.382904e-003
12799, -2.141303e-001, 3.006990e-001, 3.382907e-003
12800, -2.149481e-001, 3.012761e-001, 3.382910e-003
12801, -2.157659e-001, 3.018532e-001, 3.382913e-003
12802, -2.165837e-001, 3.024303e-001, 3.382916e-003
12803, -2.174015e-001, 3.030074e-001, 3.382919e-003
12804, -2.182193e-001, 3.035845e-001, 3.382922e-003
12805, -2.190372e-001, 3.041616e-001, 3.382925e-003
12806, -2.198550e-001, 3.047387e-001, 3.382928e-003
12807, -2.206728e-001, 3.053158e-001, 3.382932e-003
12808, -2.214906e-001, 3.058929e-001, 3.382935e-003
12809, -2.223084e-001, 3.064700e-001, 3.382939e-003
12810, -2.231262e-001, 3.070471e-001, 3.382946e-003
12811, -2.239441e-001, 3.076242e-001, 3.382962e-003
12812, -2.247620e-001, 3.082013e-001, 3.383019e-003
12813, -2.255817e-001, 3.087795e-001, 3.383145e-003
12814, -2.264042e-001, 3.093612e-001, 3.382516e-003
12815, -2.272273e-001, 3.099494e-001, 3.378658e-003
12816, -2.280441e-001, 3.105464e-001, 3.367947e-003
12817, -2.288410e-001, 3.111428e-001, 3.349966e-003
12818, -2.296423e-001, 3.117303e-001, 3.338121e-003
12819, -2.304486e-001, 3.123117e-001, 3.331431e-003
12820, -2.312586e-001, 3.128904e-001, 3.327568e-003
12821, -2.320729e-001, 3.134640e-001, 3.328092e-003
12822, -2.328935e-001, 3.140296e-001, 3.335420e-003
12823, -2.337219e-001, 3.145902e-001, 3.348358e-003
12824, -2.345568e-001, 3.151539e-001, 3.361858e-003
12825, -2.353945e-001, 3.157283e-001, 3.370662e-003
12826, -2.362254e-001, 3.163222e-001, 3.366677e-003
12827, -2.370274e-001, 3.169320e-001, 3.343405e-003
12828, -2.378240e-001, 3.175105e-001, 3.334584e-003
12829, -2.386268e-001, 3.180732e-001, 3.336697e-003
12830, -2.394321e-001, 3.186441e-001, 3.335234e-003
12831, -2.402181e-001, 3.192300e-001, 3.318233e-003
12832, -2.409624e-001, 3.198014e-001, 3.292529e-003
12833, -2.417944e-001, 3.203034e-001, 3.339409e-003
12834, -2.426173e-001, 3.208381e-001, 3.363926e-003
12835, -2.438740e-001, 3.213569e-001, 3.539349e-003
12836, -2.444924e-001, 3.222079e-001, 3.339093e-003
12837, -2.448617e-001, 3.227382e-001, 3.182835e-003
12838, -2.401728e-001, 3.139956e-001, 3.454247e-003
12839, -2.410014e-001, 3.145759e-001, 3.452155e-003
12840, -2.393484e-001, 3.134446e-001, 3.468838e-003
12841, -2.434202e-001, 3.185623e-001, 3.996877e-003
12842, -2.431881e-001, 3.192340e-001, 3.965457e-003
12843, -1.536230e-001, 2.579970e-001, 3.384669e-003
12844, -2.434252e-001, 3.203150e-001, 3.792683e-003
12845, -1.483041e-001, 2.517716e-001, 3.998433e-003
12846, -1.568887e-001, 2.603009e-001, 3.384941e-003
12847, -2.357927e-001, 3.111491e-001, 3.563422e-003
12848, -2.367495e-001, 3.117806e-001, 3.544950e-003
12849, -2.418319e-001, 3.152089e-001, 3.474329e-003
12850, -2.376404e-001, 3.123550e-001, 3.521428e-003
12851, -2.344225e-001, 3.099005e-001, 3.436354e-003
12852, -2.351672e-001, 3.104691e-001, 3.457036e-003
12853, -2.336454e-001, 3.093386e-001, 3.429750e-003
12854, -2.328522e-001, 3.087796e-001, 3.430071e-003
12855, -2.320499e-001, 3.082293e-001, 3.437817e-003
12856, -2.312362e-001, 3.076904e-001, 3.454795e-003
12857, -2.303929e-001, 3.071573e-001, 3.483890e-003
12858, -2.295491e-001, 3.065962e-001, 3.499571e-003
12859, -2.287156e-001, 3.060234e-001, 3.506534e-003
12860, -2.278904e-001, 3.054478e-001, 3.509528e-003
12861, -2.270703e-001, 3.048720e-001, 3.510807e-003
12862, -2.262529e-001, 3.042963e-001, 3.511340e-003
12863, -2.254366e-001, 3.037208e-001, 3.511553e-003
12864, -2.246209e-001, 3.031453e-001, 3.511633e-003
12865, -2.238053e-001, 3.025699e-001, 3.511660e-003
12866, -2.229899e-001, 3.019944e-001, 3.511665e-003
12867, -2.221744e-001, 3.014190e-001, 3.511662e-003
12868, -2.213590e-001, 3.008436e-001, 3.511655e-003
12869, -2.205436e-001, 3.002681e-001, 3.511648e-003
12870, -2.197282e-001, 2.996927e-001, 3.511640e-003
12871, -2.189127e-001, 2.991172e-001, 3.511632e-003
12872, -2.180973e-001, 2.985418e-001, 3.511624e-003
12873, -2.172819e-001, 2.979663e-001, 3.511615e-003
12874, -2.164665e-001, 2.973909e-001, 3.511607e-003
12875, -2.156511e-001, 2.968155e-001, 3.511599e-003
12876, -2.148357e-001, 2.962400e-001, 3.511590e-003
12877, -2.140202e-001, 2.956646e-001, 3.511582e-003
12878, -2.132048e-001, 2.950891e-001, 3.511574e-003
12879, -2.123894e-001, 2.945137e-001, 3.511565e-003
12880, -2.115740e-001, 2.939383e-001, 3.511557e-003
12881, -2.107586e-001, 2.933628e-001, 3.511548e-003
12882, -2.099432e-001, 2.927874e-001, 3.511540e-003
12883, -2.091277e-001, 2.922120e-001, 3.511531e-003
12884, -2.083123e-001, 2.916365e-001, 3.511523e-003
12885, -2.074969e-001, 2.910611e-001, 3.511514e-003
12886, -2.066815e-001, 2.904856e-001, 3.511506e-003
12887, -2.058661e-001, 2.899102e-001, 3.511497e-003
12888, -2.050507e-001, 2.893348e-001, 3.511488e-003
12889, -2.042353e-001, 2.887593e-001, 3.511480e-003
12890, -2.034198e-001, 2.881839e-001, 3.511471e-003
12891, -2.026044e-001, 2.876085e-001, 3.511462e-003
12892, -2.017890e-001, 2.870330e-001, 3.511453e-003
12893, -2.009736e-001, 2.864576e-001, 3.511445e-003
12894, -2.001582e-001, 2.858822e-001, 3.511436e-003
12895, -1.993428e-001, 2.853067e-001, 3.511427e-003
12896, -1.985274e-001, 2.847313e-001, 3.511418e-003
12897, -1.977120e-001, 2.841558e-001, 3.511409e-003
12898, -1.968966e-001, 2.835804e-001, 3.511400e-003
12899, -1.960812e-001, 2.830050e-001, 3.511391e-003
12900, -1.952658e-001, 2.824295e-001, 3.511383e-003
12901, -1.944504e-001, 2.818541e-001, 3.511374e-003
12902, -1.936349e-001, 2.812787e-001, 3.511365e-003
12903, -1.928195e-001, 2.807032e-001, 3.511356e-003
12904, -1.920041e-001, 2.801278e-001, 3.511347e-003
12905, -1.911887e-001, 2.795524e-001, 3.511338e-003
12906, -1.903733e-001, 2.789770e-001, 3.511329e-003
12907, -1.895579e-001, 2.784015e-001, 3.511320e-003
12908, -1.887425e-001, 2.778261e-001, 3.511311e-003
12909, -1.879271e-001, 2.772507e-001, 3.511302e-003
12910, -1.871117e-001, 2.766752e-001, 3.511293e-003
12911, -1.862963e-001, 2.760998e-001, 3.511284e-003
12912, -1.854809e-001, 2.755244e-001, 3.511275e-003
12913, -1.846655e-001, 2.749489e-001, 3.511266e-003
12914, -1.838501e-001, 2.743735e-001, 3.511257e-003
12915, -1.830347e-001, 2.737981e-001, 3.511248e-003
12916, -1.822193e-001, 2.732227e-001, 3.511239e-003
12917, -1.814039e-001, 2.726472e-001, 3.511230e-003
12918, -1.805885e-001, 2.720718e-001, 3.511221e-003
12919, -1.797731e-001, 2.714964e-001, 3.511212e-003
12920, -1.789577e-001, 2.709209e-001, 3.511203e-003
12921, -1.781423e-001, 2.703455e-001, 3.511194e-003
12922, -1.773269e-001, 2.697701e-001, 3.511185e-003
12923, -1.765115e-001, 2.691947e-001, 3.511176e-003
12924, -1.756961e-001, 2.686192e-001, 3.511168e-003
12925, -1.748807e-001, 2.680438e-001, 3.511159e-003
12926, -1.740654e-001, 2.674684e-001, 3.511150e-003
12927, -1.732500e-001, 2.668930e-001, 3.511142e-003
12928, -1.724346e-001, 2.663175e-001, 3.511135e-003
12929, -1.716191e-001, 2.657421e-001, 3.511132e-003
12930, -1.708037e-001, 2.651667e-001, 3.511142e-003
12931, -1.699881e-001, 2.645913e-001, 3.511197e-003
12932, -1.691725e-001, 2.640159e-001, 3.511298e-003
12933, -1.683568e-001, 2.634405e-001, 3.511381e-003
12934, -1.675413e-001, 2.628651e-001, 3.511396e-003
12935, -1.667261e-001, 2.622896e-001, 3.511316e-003
12936, -1.659109e-001, 2.617142e-001, 3.511256e-003
12937, -1.650961e-001, 2.611387e-001, 3.511024e-003
12938, -1.642814e-001, 2.605632e-001, 3.510760e-003
12939, -1.634663e-001, 2.599877e-001, 3.510614e-003
12940, -1.626507e-001, 2.594124e-001, 3.510716e-003
12941, -1.618349e-001, 2.588369e-001, 3.510840e-003
12942, -1.610191e-001, 2.582616e-001, 3.510972e-003
12943, -1.602042e-001, 2.576862e-001, 3.510845e-003
12944, -1.593896e-001, 2.571108e-001, 3.510587e-003
12945, -1.585746e-001, 2.565354e-001, 3.510438e-003
12946, -1.577593e-001, 2.559600e-001, 3.510413e-003
12947, -1.569439e-001, 2.553846e-001, 3.510464e-003
12948, -1.561286e-001, 2.548092e-001, 3.510408e-003
12949, -1.553141e-001, 2.542330e-001, 3.509775e-003
12950, -1.545000e-001, 2.536543e-001, 3.507888e-003
12951, -1.536845e-001, 2.530725e-001, 3.505029e-003
12952, -1.528707e-001, 2.524813e-001, 3.497433e-003
12953, -1.520831e-001, 2.518798e-001, 3.476425e-003
12954, -1.512994e-001, 2.512994e-001, 3.463633e-003
12955, -1.505004e-001, 2.507339e-001, 3.462842e-003
12956, -1.496620e-001, 2.501745e-001, 3.477906e-003
12957, -1.488012e-001, 2.495918e-001, 3.489348e-003
12958, -1.477292e-001, 2.489684e-001, 3.548094e-003
12959, -1.473457e-001, 2.481215e-001, 3.260026e-003
12960, -1.463610e-001, 2.478179e-001, 3.465185e-003
12961, -1.456459e-001, 2.471637e-001, 3.391803e-003
12962, -1.487384e-001, 2.525996e-001, 3.963639e-003
12963, -1.469996e-001, 2.553292e-001, 1.334549e-003
12964, -2.385061e-001, 3.129079e-001, 3.495473e-003
12965, -2.422366e-001, 3.161547e-001, 3.730743e-003
12966, -2.423330e-001, 3.174462e-001, 3.975381e-003
12967, -1.490390e-001, 2.546120e-001, 3.458930e-003
12968, -1.485566e-001, 2.537697e-001, 3.666529e-003
12969, -1.494968e-001, 2.533321e-001, 3.938408e-003
12970, -1.468233e-001, 2.487881e-001, 3.719343e-003
12971, -1.517344e-001, 2.556694e-001, 3.776343e-003
12972, -1.508622e-001, 2.552785e-001, 3.707152e-003
12973, -1.525685e-001, 2.561536e-001, 3.805056e-003
12974, -1.495275e-001, 2.550427e-001, 3.417163e-003
12975, -1.483387e-001, 2.503797e-001, 3.861026e-003
12976, -1.607316e-001, 2.618612e-001, 3.818784e-003
12977, -1.599155e-001, 2.612839e-001, 3.819150e-003
12978, -2.380217e-001, 3.137448e-001, 3.877691e-003
12979, -2.388820e-001, 3.142130e-001, 3.847190e-003
12980, -1.566482e-001, 2.589769e-001, 3.819492e-003
12981, -1.558331e-001, 2.583998e-001, 3.819977e-003
12982, -1.590983e-001, 2.607072e-001, 3.819155e-003
12983, -1.582841e-001, 2.601299e-001, 3.819853e-003
12984, -1.623665e-001, 2.630148e-001, 3.818816e-003
12985, -1.615539e-001, 2.624366e-001, 3.820027e-003
12986, -1.631845e-001, 2.635914e-001, 3.819002e-003
12987, -1.640017e-001, 2.641682e-001, 3.818943e-003
12988, -1.648192e-001, 2.647449e-001, 3.819022e-003
12989, -1.656361e-001, 2.653219e-001, 3.818848e-003
12990, -1.664537e-001, 2.658986e-001, 3.818925e-003
12991, -1.672715e-001, 2.664753e-001, 3.819039e-003
12992, -1.680893e-001, 2.670520e-001, 3.819132e-003
12993, -1.689069e-001, 2.676287e-001, 3.819193e-003
12994, -1.697244e-001, 2.682055e-001, 3.819229e-003
12995, -1.705418e-001, 2.687823e-001, 3.819248e-003
12996, -1.713592e-001, 2.693590e-001, 3.819258e-003
12997, -1.721766e-001, 2.699358e-001, 3.819263e-003
12998, -1.729940e-001, 2.705126e-001, 3.819267e-003
12999, -1.738113e-001, 2.710894e-001, 3.819269e-003
13000, -1.746287e-001, 2.716662e-001, 3.819271e-003
13001, -1.754460e-001, 2.722429e-001, 3.819272e-003
13002, -1.762634e-001, 2.728197e-001, 3.819274e-003
13003, -1.770808e-001, 2.733965e-001, 3.819275e-003
13004, -1.778981e-001, 2.739733e-001, 3.819277e-003
13005, -1.787155e-001, 2.745501e-001, 3.819278e-003
13006, -1.795328e-001, 2.751269e-001, 3.819280e-003
13007, -1.803502e-001, 2.757036e-001, 3.819281e-003
13008, -1.811675e-001, 2.762804e-001, 3.819283e-003
13009, -1.819849e-001, 2.768572e-001, 3.819284e-003
13010, -1.828022e-001, 2.774340e-001, 3.819286e-003
13011, -1.836196e-001, 2.780108e-001, 3.819287e-003
13012, -1.844370e-001, 2.785876e-001, 3.819289e-003
13013, -1.852543e-001, 2.791643e-001, 3.819290e-003
13014, -1.860717e-001, 2.797411e-001, 3.819291e-003
13015, -1.868890e-001, 2.803179e-001, 3.819293e-003
13016, -1.877064e-001, 2.808947e-001, 3.819294e-003
13017, -1.885237e-001, 2.814715e-001, 3.819295e-003
13018, -1.893411e-001, 2.820482e-001, 3.819297e-003
13019, -1.901584e-001, 2.826250e-001, 3.819298e-003
13020, -1.909758e-001, 2.832018e-001, 3.819299e-003
13021, -1.917931e-001, 2.837786e-001, 3.819300e-003
13022, -1.926105e-001, 2.843554e-001, 3.819302e-003
13023, -1.934278e-001, 2.849322e-001, 3.819303e-003
13024, -1.942452e-001, 2.855089e-001, 3.819304e-003
13025, -1.950626e-001, 2.860857e-001, 3.819306e-003
13026, -1.958799e-001, 2.866625e-001, 3.819307e-003
13027, -1.966973e-001, 2.872393e-001, 3.819308e-003
13028, -1.975146e-001, 2.878161e-001, 3.819310e-003
13029, -1.983320e-001, 2.883929e-001, 3.819311e-003
13030, -1.991493e-001, 2.889696e-001, 3.819312e-003
13031, -1.999667e-001, 2.895464e-001, 3.819313e-003
13032, -2.007840e-001, 2.901232e-001, 3.819315e-003
13033, -2.016014e-001, 2.907000e-001, 3.819316e-003
13034, -2.024187e-001, 2.912768e-001, 3.819317e-003
13035, -2.032361e-001, 2.918535e-001, 3.819318e-003
13036, -2.040534e-001, 2.924303e-001, 3.819320e-003
13037, -2.048708e-001, 2.930071e-001, 3.819321e-003
13038, -2.056882e-001, 2.935839e-001, 3.819322e-003
13039, -2.065055e-001, 2.941607e-001, 3.819323e-003
13040, -2.073229e-001, 2.947375e-001, 3.819324e-003
13041, -2.081402e-001, 2.953142e-001, 3.819325e-003
13042, -2.089576e-001, 2.958910e-001, 3.819327e-003
13043, -2.097749e-001, 2.964678e-001, 3.819328e-003
13044, -2.105923e-001, 2.970446e-001, 3.819329e-003
13045, -2.114096e-001, 2.976214e-001, 3.819330e-003
13046, -2.122270e-001, 2.981982e-001, 3.819331e-003
13047, -2.130443e-001, 2.987749e-001, 3.819333e-003
13048, -2.138617e-001, 2.993517e-001, 3.819334e-003
13049, -2.146790e-001, 2.999285e-001, 3.819335e-003
13050, -2.154964e-001, 3.005053e-001, 3.819336e-003
13051, -2.163137e-001, 3.010821e-001, 3.819337e-003
13052, -2.171311e-001, 3.016588e-001, 3.819338e-003
13053, -2.179484e-001, 3.022356e-001, 3.819339e-003
13054, -2.187658e-001, 3.028124e-001, 3.819340e-003
13055, -2.195832e-001, 3.033892e-001, 3.819341e-003
13056, -2.204005e-001, 3.039660e-001, 3.819343e-003
13057, -2.212179e-001, 3.045428e-001, 3.819344e-003
13058, -2.220352e-001, 3.051195e-001, 3.819347e-003
13059, -2.228526e-001, 3.056963e-001, 3.819352e-003
13060, -2.236700e-001, 3.062731e-001, 3.819365e-003
13061, -2.244876e-001, 3.068499e-001, 3.819404e-003
13062, -2.253066e-001, 3.074274e-001, 3.819511e-003
13063, -2.261290e-001, 3.080079e-001, 3.819490e-003
13064, -2.269564e-001, 3.085960e-001, 3.818406e-003
13065, -2.277890e-001, 3.092008e-001, 3.813965e-003
13066, -2.286154e-001, 3.098347e-001, 3.800629e-003
13067, -2.293618e-001, 3.104680e-001, 3.770939e-003
13068, -2.301356e-001, 3.110668e-001, 3.755411e-003
13069, -2.309249e-001, 3.116467e-001, 3.748506e-003
13070, -2.317255e-001, 3.122183e-001, 3.746480e-003
13071, -2.325371e-001, 3.127789e-001, 3.750169e-003
13072, -2.333639e-001, 3.133233e-001, 3.761843e-003
13073, -2.342122e-001, 3.138580e-001, 3.780308e-003
13074, -2.350734e-001, 3.144047e-001, 3.797203e-003
13075, -2.359412e-001, 3.149770e-001, 3.807883e-003
13076, -2.368022e-001, 3.155979e-001, 3.804382e-003
13077, -2.375560e-001, 3.162902e-001, 3.759290e-003
13078, -2.383060e-001, 3.168541e-001, 3.748900e-003
13079, -2.390749e-001, 3.174011e-001, 3.747556e-003
13080, -2.398616e-001, 3.179607e-001, 3.746198e-003
13081, -2.406524e-001, 3.185371e-001, 3.740512e-003
13082, -2.412682e-001, 3.191344e-001, 3.687401e-003
13083, -2.422452e-001, 3.194955e-001, 3.789034e-003
13084, -1.490911e-001, 2.509337e-001, 3.866077e-003
13085, -2.454383e-001, 3.227694e-001, 3.394648e-003
13086, -2.425192e-001, 3.183954e-001, 3.993664e-003
13087, -2.396988e-001, 3.147326e-001, 3.833664e-003
13088, -2.404868e-001, 3.153340e-001, 3.844520e-003
13089, -2.346402e-001, 3.109764e-001, 3.784983e-003
13090, -2.352616e-001, 3.121515e-001, 3.939697e-003
13091, -1.574707e-001, 2.595524e-001, 3.820723e-003
13092, -2.361983e-001, 3.126643e-001, 3.916499e-003
13093, -2.371127e-001, 3.132071e-001, 3.898172e-003
13094, -2.339433e-001, 3.105339e-001, 3.798489e-003
13095, -2.331830e-001, 3.100179e-001, 3.803990e-003
13096, -2.308172e-001, 3.084581e-001, 3.831970e-003
13097, -2.316159e-001, 3.089549e-001, 3.815205e-003
13098, -2.299050e-001, 3.080073e-001, 3.875682e-003
13099, -2.290184e-001, 3.074411e-001, 3.887749e-003
13100, -2.281666e-001, 3.068589e-001, 3.891462e-003
13101, -2.273331e-001, 3.062780e-001, 3.892858e-003
13102, -2.265091e-001, 3.056997e-001, 3.893476e-003
13103, -2.256897e-001, 3.051229e-001, 3.893757e-003
13104, -2.248723e-001, 3.045467e-001, 3.893876e-003
13105, -2.240558e-001, 3.039707e-001, 3.893924e-003
13106, -2.232395e-001, 3.033948e-001, 3.893941e-003
13107, -2.224233e-001, 3.028189e-001, 3.893946e-003
13108, -2.216072e-001, 3.022430e-001, 3.893947e-003
13109, -2.207911e-001, 3.016671e-001, 3.893945e-003
13110, -2.199750e-001, 3.010912e-001, 3.893943e-003
13111, -2.191589e-001, 3.005153e-001, 3.893940e-003
13112, -2.183428e-001, 2.999394e-001, 3.893938e-003
13113, -2.175268e-001, 2.993634e-001, 3.893935e-003
13114, -2.167107e-001, 2.987875e-001, 3.893932e-003
13115, -2.158946e-001, 2.982116e-001, 3.893930e-003
13116, -2.150785e-001, 2.976357e-001, 3.893927e-003
13117, -2.142624e-001, 2.970598e-001, 3.893924e-003
13118, -2.134463e-001, 2.964839e-001, 3.893921e-003
13119, -2.126302e-001, 2.959080e-001, 3.893919e-003
13120, -2.118141e-001, 2.953321e-001, 3.893916e-003
13121, -2.109980e-001, 2.947562e-001, 3.893913e-003
13122, -2.101820e-001, 2.941803e-001, 3.893910e-003
13123, -2.093659e-001, 2.936044e-001, 3.893908e-003
13124, -2.085498e-001, 2.930285e-001, 3.893905e-003
13125, -2.077337e-001, 2.924525e-001, 3.893902e-003
13126, -2.069176e-001, 2.918766e-001, 3.893899e-003
13127, -2.061015e-001, 2.913007e-001, 3.893897e-003
13128, -2.052854e-001, 2.907248e-001, 3.893894e-003
13129, -2.044694e-001, 2.901489e-001, 3.893891e-003
13130, -2.036533e-001, 2.895730e-001, 3.893888e-003
13131, -2.028372e-001, 2.889971e-001, 3.893885e-003
13132, -2.020211e-001, 2.884212e-001, 3.893882e-003
13133, -2.012050e-001, 2.878453e-001, 3.893880e-003
13134, -2.003889e-001, 2.872694e-001, 3.893877e-003
13135, -1.995729e-001, 2.866935e-001, 3.893874e-003
13136, -1.987568e-001, 2.861176e-001, 3.893871e-003
13137, -1.979407e-001, 2.855417e-001, 3.893868e-003
13138, -1.971246e-001, 2.849658e-001, 3.893865e-003
13139, -1.963085e-001, 2.843899e-001, 3.893862e-003
13140, -1.954924e-001, 2.838140e-001, 3.893860e-003
13141, -1.946764e-001, 2.832381e-001, 3.893857e-003
13142, -1.938603e-001, 2.826622e-001, 3.893854e-003
13143, -1.930442e-001, 2.820863e-001, 3.893851e-003
13144, -1.922281e-001, 2.815103e-001, 3.893848e-003
13145, -1.914120e-001, 2.809344e-001, 3.893845e-003
13146, -1.905960e-001, 2.803585e-001, 3.893842e-003
13147, -1.897799e-001, 2.797826e-001, 3.893839e-003
13148, -1.889638e-001, 2.792067e-001, 3.893836e-003
13149, -1.881477e-001, 2.786308e-001, 3.893834e-003
13150, -1.873317e-001, 2.780549e-001, 3.893831e-003
13151, -1.865156e-001, 2.774790e-001, 3.893828e-003
13152, -1.856995e-001, 2.769031e-001, 3.893825e-003
13153, -1.848834e-001, 2.763272e-001, 3.893822e-003
13154, -1.840674e-001, 2.757513e-001, 3.893819e-003
13155, -1.832513e-001, 2.751754e-001, 3.893816e-003
13156, -1.824352e-001, 2.745995e-001, 3.893813e-003
13157, -1.816191e-001, 2.740236e-001, 3.893810e-003
13158, -1.808031e-001, 2.734477e-001, 3.893808e-003
13159, -1.799870e-001, 2.728718e-001, 3.893805e-003
13160, -1.791709e-001, 2.722959e-001, 3.893802e-003
13161, -1.783548e-001, 2.717200e-001, 3.893799e-003
13162, -1.775388e-001, 2.711441e-001, 3.893796e-003
13163, -1.767227e-001, 2.705682e-001, 3.893793e-003
13164, -1.759066e-001, 2.699923e-001, 3.893791e-003
13165, -1.750905e-001, 2.694164e-001, 3.893788e-003
13166, -1.742745e-001, 2.688405e-001, 3.893785e-003
13167, -1.734584e-001, 2.682646e-001, 3.893783e-003
13168, -1.726423e-001, 2.676887e-001, 3.893781e-003
13169, -1.718262e-001, 2.671129e-001, 3.893782e-003
13170, -1.710101e-001, 2.665370e-001, 3.893789e-003
13171, -1.701939e-001, 2.659611e-001, 3.893812e-003
13172, -1.693775e-001, 2.653853e-001, 3.893862e-003
13173, -1.685610e-001, 2.648095e-001, 3.893934e-003
13174, -1.677445e-001, 2.642337e-001, 3.894007e-003
13175, -1.669282e-001, 2.636579e-001, 3.894048e-003
13176, -1.661128e-001, 2.630816e-001, 3.893903e-003
13177, -1.652968e-001, 2.625059e-001, 3.893909e-003
13178, -1.644818e-001, 2.619297e-001, 3.893718e-003
13179, -1.636668e-001, 2.613535e-001, 3.893516e-003
13180, -1.628514e-001, 2.607774e-001, 3.893377e-003
13181, -1.620344e-001, 2.602018e-001, 3.893548e-003
13182, -1.612181e-001, 2.596259e-001, 3.893581e-003
13183, -1.604015e-001, 2.590503e-001, 3.893697e-003
13184, -1.595865e-001, 2.584742e-001, 3.893520e-003
13185, -1.587718e-001, 2.578982e-001, 3.893313e-003
13186, -1.579562e-001, 2.573223e-001, 3.893235e-003
13187, -1.571405e-001, 2.567463e-001, 3.893166e-003
13188, -1.563244e-001, 2.561707e-001, 3.893215e-003
13189, -1.555095e-001, 2.555946e-001, 3.893037e-003
13190, -1.546941e-001, 2.550185e-001, 3.892900e-003
13191, -1.538728e-001, 2.544427e-001, 3.893625e-003
13192, -1.530353e-001, 2.538643e-001, 3.896030e-003
13193, -1.521827e-001, 2.532541e-001, 3.894403e-003
13194, -1.514513e-001, 2.525777e-001, 3.861359e-003
13195, -1.507178e-001, 2.519932e-001, 3.846171e-003
13196, -1.499607e-001, 2.514428e-001, 3.842364e-003
13197, -1.494592e-001, 2.521520e-001, 3.992598e-003
13198, -1.542024e-001, 2.572512e-001, 3.819439e-003
13199, -1.533901e-001, 2.566904e-001, 3.816250e-003
13200, -1.550201e-001, 2.578238e-001, 3.820558e-003
13201, -2.412542e-001, 3.162616e-001, 3.921404e-003
13202, -2.412791e-001, 3.176711e-001, 3.984812e-003
13203, -2.324032e-001, 3.094793e-001, 3.807094e-003
13204, -1.499289e-001, 2.543008e-001, 3.802411e-003
13205, -1.500502e-001, 2.550622e-001, 3.575233e-003
13206, -1.500979e-001, 2.526690e-001, 3.995530e-003
13207, -2.418540e-001, 3.187419e-001, 3.899346e-003
13208, -2.311712e-001, 3.096947e-001, 3.985447e-003
13209, -2.319297e-001, 3.102127e-001, 3.984219e-003
13210, -1.531928e-001, 2.553031e-001, 3.996006e-003
13211, -1.522966e-001, 2.547576e-001, 3.992196e-003
13212, -1.597441e-001, 2.598855e-001, 3.997354e-003
13213, -1.589297e-001, 2.593084e-001, 3.997427e-003
13214, -1.613780e-001, 2.610380e-001, 3.997371e-003
13215, -1.605623e-001, 2.604605e-001, 3.997425e-003
13216, -2.399344e-001, 3.159620e-001, 3.990685e-003
13217, -2.404927e-001, 3.164739e-001, 3.996105e-003
13218, -2.327100e-001, 3.107480e-001, 3.983080e-003
13219, -1.556656e-001, 2.570038e-001, 3.997462e-003
13220, -1.548501e-001, 2.564295e-001, 3.997429e-003
13221, -1.646431e-001, 2.633441e-001, 3.997311e-003
13222, -1.638278e-001, 2.627669e-001, 3.997366e-003
13223, -1.630122e-001, 2.621900e-001, 3.997405e-003
13224, -1.662759e-001, 2.644970e-001, 3.997288e-003
13225, -1.654611e-001, 2.639192e-001, 3.997377e-003
13226, -1.670935e-001, 2.650728e-001, 3.997326e-003
13227, -1.679108e-001, 2.656489e-001, 3.997346e-003
13228, -1.687280e-001, 2.662251e-001, 3.997359e-003
13229, -1.695450e-001, 2.668014e-001, 3.997368e-003
13230, -1.703619e-001, 2.673777e-001, 3.997372e-003
13231, -1.711787e-001, 2.679540e-001, 3.997375e-003
13232, -1.719955e-001, 2.685304e-001, 3.997376e-003
13233, -1.728123e-001, 2.691067e-001, 3.997376e-003
13234, -1.736290e-001, 2.696831e-001, 3.997376e-003
13235, -1.744458e-001, 2.702594e-001, 3.997376e-003
13236, -1.752625e-001, 2.708358e-001, 3.997376e-003
13237, -1.760792e-001, 2.714121e-001, 3.997376e-003
13238, -1.768960e-001, 2.719885e-001, 3.997376e-003
13239, -1.777127e-001, 2.725648e-001, 3.997376e-003
13240, -1.785295e-001, 2.731412e-001, 3.997376e-003
13241, -1.793462e-001, 2.737176e-001, 3.997375e-003
13242, -1.801629e-001, 2.742939e-001, 3.997375e-003
13243, -1.809797e-001, 2.748703e-001, 3.997375e-003
13244, -1.817964e-001, 2.754466e-001, 3.997375e-003
13245, -1.826132e-001, 2.760230e-001, 3.997375e-003
13246, -1.834299e-001, 2.765993e-001, 3.997375e-003
13247, -1.842466e-001, 2.771757e-001, 3.997375e-003
13248, -1.850634e-001, 2.777521e-001, 3.997375e-003
13249, -1.858801e-001, 2.783284e-001, 3.997375e-003
13250, -1.866968e-001, 2.789048e-001, 3.997374e-003
13251, -1.875136e-001, 2.794811e-001, 3.997374e-003
13252, -1.883303e-001, 2.800575e-001, 3.997374e-003
13253, -1.891471e-001, 2.806338e-001, 3.997374e-003
13254, -1.899638e-001, 2.812102e-001, 3.997374e-003
13255, -1.907805e-001, 2.817866e-001, 3.997374e-003
13256, -1.915973e-001, 2.823629e-001, 3.997374e-003
13257, -1.924140e-001, 2.829393e-001, 3.997374e-003
13258, -1.932308e-001, 2.835156e-001, 3.997373e-003
13259, -1.940475e-001, 2.840920e-001, 3.997373e-003
13260, -1.948642e-001, 2.846684e-001, 3.997373e-003
13261, -1.956810e-001, 2.852447e-001, 3.997373e-003
13262, -1.964977e-001, 2.858211e-001, 3.997373e-003
13263, -1.973145e-001, 2.863974e-001, 3.997373e-003
13264, -1.981312e-001, 2.869738e-001, 3.997373e-003
13265, -1.989480e-001, 2.875502e-001, 3.997373e-003
13266, -1.997647e-001, 2.881265e-001, 3.997372e-003
13267, -2.005814e-001, 2.887029e-001, 3.997372e-003
13268, -2.013982e-001, 2.892792e-001, 3.997372e-003
13269, -2.022149e-001, 2.898556e-001, 3.997372e-003
13270, -2.030317e-001, 2.904320e-001, 3.997372e-003
13271, -2.038484e-001, 2.910083e-001, 3.997372e-003
13272, -2.046651e-001, 2.915847e-001, 3.997372e-003
13273, -2.054819e-001, 2.921610e-001, 3.997372e-003
13274, -2.062986e-001, 2.927374e-001, 3.997371e-003
13275, -2.071154e-001, 2.933138e-001, 3.997371e-003
13276, -2.079321e-001, 2.938901e-001, 3.997371e-003
13277, -2.087489e-001, 2.944665e-001, 3.997371e-003
13278, -2.095656e-001, 2.950428e-001, 3.997371e-003
13279, -2.103823e-001, 2.956192e-001, 3.997371e-003
13280, -2.111991e-001, 2.961956e-001, 3.997371e-003
13281, -2.120158e-001, 2.967719e-001, 3.997371e-003
13282, -2.128326e-001, 2.973483e-001, 3.997370e-003
13283, -2.136493e-001, 2.979246e-001, 3.997370e-003
13284, -2.144661e-001, 2.985010e-001, 3.997370e-003
13285, -2.152828e-001, 2.990774e-001, 3.997370e-003
13286, -2.160996e-001, 2.996537e-001, 3.997370e-003
13287, -2.169163e-001, 3.002301e-001, 3.997370e-003
13288, -2.177330e-001, 3.008064e-001, 3.997370e-003
13289, -2.185498e-001, 3.013828e-001, 3.997370e-003
13290, -2.193665e-001, 3.019592e-001, 3.997369e-003
13291, -2.201833e-001, 3.025355e-001, 3.997369e-003
13292, -2.210000e-001, 3.031119e-001, 3.997369e-003
13293, -2.218168e-001, 3.036883e-001, 3.997370e-003
13294, -2.226336e-001, 3.042646e-001, 3.997370e-003
13295, -2.234504e-001, 3.048410e-001, 3.997372e-003
13296, -2.242674e-001, 3.054174e-001, 3.997377e-003
13297, -2.250852e-001, 3.059940e-001, 3.997390e-003
13298, -2.259053e-001, 3.065719e-001, 3.997415e-003
13299, -2.267304e-001, 3.071535e-001, 3.997435e-003
13300, -2.275658e-001, 3.077450e-001, 3.997376e-003
13301, -2.284240e-001, 3.083629e-001, 3.996998e-003
13302, -2.293442e-001, 3.090687e-001, 3.994944e-003
13303, -2.299233e-001, 3.097851e-001, 3.974332e-003
13304, -2.306599e-001, 3.103775e-001, 3.967129e-003
13305, -2.314289e-001, 3.109385e-001, 3.965160e-003
13306, -2.322179e-001, 3.114924e-001, 3.965474e-003
13307, -2.330230e-001, 3.120332e-001, 3.968365e-003
13308, -2.338538e-001, 3.125455e-001, 3.975538e-003
13309, -2.347366e-001, 3.130346e-001, 3.986175e-003
13310, -2.356374e-001, 3.135583e-001, 3.992749e-003
13311, -2.365577e-001, 3.141154e-001, 3.996584e-003
13312, -2.375672e-001, 3.147147e-001, 3.999335e-003
13313, -2.381429e-001, 3.157086e-001, 3.961579e-003
13314, -2.387961e-001, 3.161791e-001, 3.960482e-003
13315, -2.395137e-001, 3.166905e-001, 3.959902e-003
13316, -2.402751e-001, 3.172100e-001, 3.961953e-003
13317, -2.334983e-001, 3.112639e-001, 3.979896e-003
13318, -2.392206e-001, 3.154622e-001, 3.990899e-003
13319, -1.511987e-001, 2.541792e-001, 3.978915e-003
13320, -2.384392e-001, 3.149949e-001, 3.994950e-003
13321, -1.581149e-001, 2.587316e-001, 3.997479e-003
13322, -1.507315e-001, 2.531982e-001, 3.998139e-003
13323, -2.304908e-001, 3.092444e-001, 3.987457e-003
13324, -1.621973e-001, 2.616127e-001, 3.997471e-003
13325, -1.572980e-001, 2.581553e-001, 3.997475e-003
13326, -1.564827e-001, 2.575785e-001, 3.997519e-003
13327, -1.540297e-001, 2.558624e-001, 3.997068e-003
13328, -2.343091e-001, 3.117376e-001, 3.970979e-003
13329, -1.468534e-001, 2.482372e-001, 3.498410e-003
13330, -1.480522e-001, 2.540958e-001, 3.369135e-003
13331, -1.494145e-001, 2.553588e-001, 3.198024e-003
13332, -2.430862e-001, 3.181550e-001, 3.988861e-003
13333, -1.361482e-001, 2.353422e-001, 1.088938e-003
13334, -1.361291e-001, 2.348885e-001, 2.101599e-003
13335, -1.356288e-001, 2.343742e-001, 2.869947e-003
13336, -1.351032e-001, 2.337480e-001, 3.432148e-003
13337, -1.346054e-001, 2.330390e-001, 3.800160e-003
13338, -1.341760e-001, 2.322611e-001, 3.980780e-003
13339, -1.338481e-001, 2.314326e-001, 3.969800e-003
13340, -1.336456e-001, 2.305898e-001, 3.762657e-003
13341, -1.335759e-001, 2.297844e-001, 3.368807e-003
13342, -1.335965e-001, 2.290608e-001, 2.801184e-003
13343, -1.336819e-001, 2.284514e-001, 2.061567e-003
13344, -1.338227e-001, 2.279957e-001, 1.127260e-003
13345, -1.377982e-001, 2.349888e-001, 9.238636e-004
13346, -1.386553e-001, 2.347652e-001, 9.913892e-004
13347, -1.395736e-001, 2.345387e-001, 1.011381e-003
13348, -1.405252e-001, 2.343079e-001, 1.017139e-003
13349, -1.414900e-001, 2.340749e-001, 1.019301e-003
13350, -1.424597e-001, 2.338410e-001, 1.020393e-003
13351, -1.434311e-001, 2.336068e-001, 1.020835e-003
13352, -1.444033e-001, 2.333726e-001, 1.020958e-003
13353, -1.453757e-001, 2.331383e-001, 1.020995e-003
13354, -1.463482e-001, 2.329040e-001, 1.020985e-003
13355, -1.473206e-001, 2.326698e-001, 1.020944e-003
13356, -1.482931e-001, 2.324355e-001, 1.020947e-003
13357, -1.492656e-001, 2.322012e-001, 1.020976e-003
13358, -1.502380e-001, 2.319670e-001, 1.020964e-003
13359, -1.512105e-001, 2.317327e-001, 1.020955e-003
13360, -1.521829e-001, 2.314984e-001, 1.020942e-003
13361, -1.531553e-001, 2.312642e-001, 1.020952e-003
13362, -1.541278e-001, 2.310299e-001, 1.020948e-003
13363, -1.551002e-001, 2.307956e-001, 1.020947e-003
13364, -1.560727e-001, 2.305614e-001, 1.020953e-003
13365, -1.570451e-001, 2.303271e-001, 1.020961e-003
13366, -1.580176e-001, 2.300928e-001, 1.020967e-003
13367, -1.589900e-001, 2.298586e-001, 1.020971e-003
13368, -1.599625e-001, 2.296243e-001, 1.020973e-003
13369, -1.609349e-001, 2.293900e-001, 1.020974e-003
13370, -1.619073e-001, 2.291558e-001, 1.020975e-003
13371, -1.628798e-001, 2.289215e-001, 1.020975e-003
13372, -1.638522e-001, 2.286872e-001, 1.020975e-003
13373, -1.648247e-001, 2.284530e-001, 1.020976e-003
13374, -1.657971e-001, 2.282187e-001, 1.020976e-003
13375, -1.667696e-001, 2.279844e-001, 1.020976e-003
13376, -1.677420e-001, 2.277502e-001, 1.020976e-003
13377, -1.687145e-001, 2.275159e-001, 1.020976e-003
13378, -1.696869e-001, 2.272816e-001, 1.020976e-003
13379, -1.706594e-001, 2.270473e-001, 1.020977e-003
13380, -1.716318e-001, 2.268131e-001, 1.020977e-003
13381, -1.726042e-001, 2.265788e-001, 1.020977e-003
13382, -1.735767e-001, 2.263445e-001, 1.020977e-003
13383, -1.745491e-001, 2.261103e-001, 1.020977e-003
13384, -1.755216e-001, 2.258760e-001, 1.020977e-003
13385, -1.764940e-001, 2.256417e-001, 1.020977e-003
13386, -1.774665e-001, 2.254075e-001, 1.020978e-003
13387, -1.784389e-001, 2.251732e-001, 1.020978e-003
13388, -1.794114e-001, 2.249389e-001, 1.020978e-003
13389, -1.803838e-001, 2.247047e-001, 1.020978e-003
13390, -1.813562e-001, 2.244704e-001, 1.020978e-003
13391, -1.823287e-001, 2.242361e-001, 1.020978e-003
13392, -1.833011e-001, 2.240019e-001, 1.020979e-003
13393, -1.842736e-001, 2.237676e-001, 1.020979e-003
13394, -1.852460e-001, 2.235333e-001, 1.020979e-003
13395, -1.862185e-001, 2.232991e-001, 1.020979e-003
13396, -1.871909e-001, 2.230648e-001, 1.020979e-003
13397, -1.881634e-001, 2.228305e-001, 1.020979e-003
13398, -1.891358e-001, 2.225963e-001, 1.020979e-003
13399, -1.901083e-001, 2.223620e-001, 1.020980e-003
13400, -1.910807e-001, 2.221277e-001, 1.020980e-003
13401, -1.920531e-001, 2.218935e-001, 1.020980e-003
13402, -1.930256e-001, 2.216592e-001, 1.020980e-003
13403, -1.939980e-001, 2.214249e-001, 1.020980e-003
13404, -1.949705e-001, 2.211907e-001, 1.020980e-003
13405, -1.959429e-001, 2.209564e-001, 1.020980e-003
13406, -1.969154e-001, 2.207221e-001, 1.020981e-003
13407, -1.978878e-001, 2.204879e-001, 1.020981e-003
13408, -1.988603e-001, 2.202536e-001, 1.020981e-003
13409, -1.998327e-001, 2.200193e-001, 1.020986e-003
13410, -2.008055e-001, 2.197849e-001, 1.021320e-003
13411, -2.017785e-001, 2.195503e-001, 1.021933e-003
13412, -2.027511e-001, 2.193160e-001, 1.021842e-003
13413, -2.037233e-001, 2.190820e-001, 1.021373e-003
13414, -2.046955e-001, 2.188479e-001, 1.020911e-003
13415, -2.056677e-001, 2.186138e-001, 1.020537e-003
13416, -2.066400e-001, 2.183796e-001, 1.020345e-003
13417, -2.076127e-001, 2.181453e-001, 1.020019e-003
13418, -2.085866e-001, 2.179120e-001, 1.015318e-003
13419, -2.095620e-001, 2.176811e-001, 9.999964e-004
13420, -2.105415e-001, 2.174521e-001, 9.734086e-004
13421, -2.115166e-001, 2.172252e-001, 9.418840e-004
13422, -2.124642e-001, 2.170063e-001, 9.032173e-004
13423, -2.132026e-001, 2.168565e-001, 7.763613e-004
13424, -2.123501e-001, 2.090450e-001, 1.011686e-003
13425, -2.125633e-001, 2.093822e-001, 1.950483e-003
13426, -2.128520e-001, 2.099172e-001, 2.750293e-003
13427, -2.131720e-001, 2.106038e-001, 3.365360e-003
13428, -2.134680e-001, 2.113913e-001, 3.773447e-003
13429, -2.137041e-001, 2.122432e-001, 3.975327e-003
13430, -2.138532e-001, 2.131176e-001, 3.975567e-003
13431, -2.139093e-001, 2.139577e-001, 3.792608e-003
13432, -2.138845e-001, 2.147000e-001, 3.471515e-003
13433, -2.138211e-001, 2.152888e-001, 3.086200e-003
13434, -2.139080e-001, 2.162726e-001, 1.897108e-003
13435, -2.135928e-001, 2.165942e-001, 1.363691e-003
13436, -2.113938e-001, 2.092854e-001, 1.048345e-003
13437, -2.104194e-001, 2.095301e-001, 1.083230e-003
13438, -2.094310e-001, 2.097737e-001, 1.102004e-003
13439, -2.084278e-001, 2.100044e-001, 1.064134e-003
13440, -2.074468e-001, 2.102323e-001, 1.034056e-003
13441, -2.064753e-001, 2.104616e-001, 1.016449e-003
13442, -2.055068e-001, 2.106925e-001, 1.007614e-003
13443, -2.045392e-001, 2.109245e-001, 1.003602e-003
13444, -2.035719e-001, 2.111571e-001, 1.001982e-003
13445, -2.026047e-001, 2.113900e-001, 1.001304e-003
13446, -2.016375e-001, 2.116229e-001, 1.001115e-003
13447, -2.006705e-001, 2.118559e-001, 1.001353e-003
13448, -1.997037e-001, 2.120890e-001, 1.002072e-003
13449, -1.987370e-001, 2.123221e-001, 1.002944e-003
13450, -1.977701e-001, 2.125552e-001, 1.003648e-003
13451, -1.968032e-001, 2.127883e-001, 1.004098e-003
13452, -1.958362e-001, 2.130213e-001, 1.004345e-003
13453, -1.948691e-001, 2.132543e-001, 1.004466e-003
13454, -1.939020e-001, 2.134873e-001, 1.004520e-003
13455, -1.929349e-001, 2.137203e-001, 1.004542e-003
13456, -1.919677e-001, 2.139533e-001, 1.004550e-003
13457, -1.910006e-001, 2.141863e-001, 1.004551e-003
13458, -1.900335e-001, 2.144193e-001, 1.004549e-003
13459, -1.890663e-001, 2.146523e-001, 1.004547e-003
13460, -1.880992e-001, 2.148853e-001, 1.004544e-003
13461, -1.871321e-001, 2.151183e-001, 1.004541e-003
13462, -1.861649e-001, 2.153512e-001, 1.004537e-003
13463, -1.851978e-001, 2.155842e-001, 1.004534e-003
13464, -1.842307e-001, 2.158172e-001, 1.004531e-003
13465, -1.832636e-001, 2.160502e-001, 1.004528e-003
13466, -1.822964e-001, 2.162832e-001, 1.004525e-003
13467, -1.813293e-001, 2.165162e-001, 1.004521e-003
13468, -1.803622e-001, 2.167492e-001, 1.004518e-003
13469, -1.793950e-001, 2.169821e-001, 1.004515e-003
13470, -1.784279e-001, 2.172151e-001, 1.004512e-003
13471, -1.774608e-001, 2.174481e-001, 1.004508e-003
13472, -1.764937e-001, 2.176811e-001, 1.004505e-003
13473, -1.755265e-001, 2.179141e-001, 1.004502e-003
13474, -1.745594e-001, 2.181471e-001, 1.004498e-003
13475, -1.735923e-001, 2.183801e-001, 1.004495e-003
13476, -1.726251e-001, 2.186130e-001, 1.004492e-003
13477, -1.716580e-001, 2.188460e-001, 1.004488e-003
13478, -1.706909e-001, 2.190790e-001, 1.004485e-003
13479, -1.697238e-001, 2.193120e-001, 1.004482e-003
13480, -1.687566e-001, 2.195450e-001, 1.004478e-003
13481, -1.677895e-001, 2.197780e-001, 1.004475e-003
13482, -1.668224e-001, 2.200110e-001, 1.004471e-003
13483, -1.658552e-001, 2.202439e-001, 1.004468e-003
13484, -1.648881e-001, 2.204769e-001, 1.004464e-003
13485, -1.639210e-001, 2.207099e-001, 1.004461e-003
13486, -1.629539e-001, 2.209429e-001, 1.004458e-003
13487, -1.619867e-001, 2.211759e-001, 1.004454e-003
13488, -1.610196e-001, 2.214089e-001, 1.004451e-003
13489, -1.600525e-001, 2.216419e-001, 1.004447e-003
13490, -1.590853e-001, 2.218748e-001, 1.004443e-003
13491, -1.581182e-001, 2.221078e-001, 1.004441e-003
13492, -1.571511e-001, 2.223408e-001, 1.004438e-003
13493, -1.561840e-001, 2.225738e-001, 1.004433e-003
13494, -1.552168e-001, 2.228068e-001, 1.004430e-003
13495, -1.542497e-001, 2.230398e-001, 1.004427e-003
13496, -1.532826e-001, 2.232728e-001, 1.004427e-003
13497, -1.523155e-001, 2.235057e-001, 1.004434e-003
13498, -1.513483e-001, 2.237387e-001, 1.004426e-003
13499, -1.503812e-001, 2.239717e-001, 1.004427e-003
13500, -1.494141e-001, 2.242047e-001, 1.004425e-003
13501, -1.484470e-001, 2.244377e-001, 1.004418e-003
13502, -1.474798e-001, 2.246707e-001, 1.004409e-003
13503, -1.465127e-001, 2.249036e-001, 1.004392e-003
13504, -1.455456e-001, 2.251366e-001, 1.004394e-003
13505, -1.445785e-001, 2.253696e-001, 1.004398e-003
13506, -1.436113e-001, 2.256026e-001, 1.004386e-003
13507, -1.426442e-001, 2.258356e-001, 1.004388e-003
13508, -1.416771e-001, 2.260686e-001, 1.004389e-003
13509, -1.407100e-001, 2.263015e-001, 1.004362e-003
13510, -1.397424e-001, 2.265347e-001, 1.004739e-003
13511, -1.387746e-001, 2.267678e-001, 1.004254e-003
13512, -1.378094e-001, 2.270004e-001, 1.004725e-003
13513, -1.368564e-001, 2.272342e-001, 1.020444e-003
13514, -1.359173e-001, 2.274790e-001, 1.086656e-003
13515, -1.349003e-001, 2.278122e-001, 1.354114e-003
13516, -1.370090e-001, 2.345481e-001, 2.291559e-003
13517, -1.364897e-001, 2.339227e-001, 3.082681e-003
13518, -1.359693e-001, 2.332511e-001, 3.585040e-003
13519, -1.354946e-001, 2.325565e-001, 3.876141e-003
13520, -1.350884e-001, 2.318397e-001, 3.995214e-003
13521, -1.347610e-001, 2.311073e-001, 3.955795e-003
13522, -1.345398e-001, 2.303756e-001, 3.763069e-003
13523, -1.344808e-001, 2.296592e-001, 3.424869e-003
13524, -1.344924e-001, 2.289792e-001, 2.928289e-003
13525, -1.345842e-001, 2.283689e-001, 2.265323e-003
13526, -1.394716e-001, 2.341701e-001, 1.958332e-003
13527, -1.385878e-001, 2.343941e-001, 1.939042e-003
13528, -1.404152e-001, 2.339416e-001, 1.960318e-003
13529, -1.413760e-001, 2.337078e-001, 1.964382e-003
13530, -1.423438e-001, 2.334729e-001, 1.967502e-003
13531, -1.433143e-001, 2.332383e-001, 1.968721e-003
13532, -1.442866e-001, 2.330039e-001, 1.969162e-003
13533, -1.452590e-001, 2.327695e-001, 1.969301e-003
13534, -1.462316e-001, 2.325353e-001, 1.969259e-003
13535, -1.472041e-001, 2.323010e-001, 1.969163e-003
13536, -1.481766e-001, 2.320667e-001, 1.969314e-003
13537, -1.491491e-001, 2.318323e-001, 1.969432e-003
13538, -1.501215e-001, 2.315981e-001, 1.969331e-003
13539, -1.510938e-001, 2.313639e-001, 1.969233e-003
13540, -1.520662e-001, 2.311297e-001, 1.969232e-003
13541, -1.530386e-001, 2.308954e-001, 1.969252e-003
13542, -1.540110e-001, 2.306612e-001, 1.969235e-003
13543, -1.549834e-001, 2.304269e-001, 1.969254e-003
13544, -1.559559e-001, 2.301926e-001, 1.969301e-003
13545, -1.569283e-001, 2.299583e-001, 1.969350e-003
13546, -1.579007e-001, 2.297240e-001, 1.969386e-003
13547, -1.588731e-001, 2.294898e-001, 1.969408e-003
13548, -1.598455e-001, 2.292555e-001, 1.969421e-003
13549, -1.608179e-001, 2.290212e-001, 1.969428e-003
13550, -1.617904e-001, 2.287870e-001, 1.969431e-003
13551, -1.627628e-001, 2.285527e-001, 1.969434e-003
13552, -1.637352e-001, 2.283184e-001, 1.969435e-003
13553, -1.647076e-001, 2.280842e-001, 1.969437e-003
13554, -1.656800e-001, 2.278499e-001, 1.969438e-003
13555, -1.666524e-001, 2.276157e-001, 1.969440e-003
13556, -1.676248e-001, 2.273814e-001, 1.969441e-003
13557, -1.685972e-001, 2.271471e-001, 1.969442e-003
13558, -1.695696e-001, 2.269129e-001, 1.969443e-003
13559, -1.705421e-001, 2.266786e-001, 1.969445e-003
13560, -1.715145e-001, 2.264444e-001, 1.969446e-003
13561, -1.724869e-001, 2.262101e-001, 1.969447e-003
13562, -1.734593e-001, 2.259758e-001, 1.969448e-003
13563, -1.744317e-001, 2.257416e-001, 1.969450e-003
13564, -1.754041e-001, 2.255073e-001, 1.969451e-003
13565, -1.763765e-001, 2.252731e-001, 1.969452e-003
13566, -1.773489e-001, 2.250388e-001, 1.969453e-003
13567, -1.783213e-001, 2.248045e-001, 1.969455e-003
13568, -1.792937e-001, 2.245703e-001, 1.969456e-003
13569, -1.802662e-001, 2.243360e-001, 1.969457e-003
13570, -1.812386e-001, 2.241018e-001, 1.969458e-003
13571, -1.822110e-001, 2.238675e-001, 1.969460e-003
13572, -1.831834e-001, 2.236332e-001, 1.969461e-003
13573, -1.841558e-001, 2.233990e-001, 1.969462e-003
13574, -1.851282e-001, 2.231647e-001, 1.969463e-003
13575, -1.861006e-001, 2.229305e-001, 1.969464e-003
13576, -1.870730e-001, 2.226962e-001, 1.969466e-003
13577, -1.880454e-001, 2.224620e-001, 1.969467e-003
13578, -1.890178e-001, 2.222277e-001, 1.969468e-003
13579, -1.899902e-001, 2.219934e-001, 1.969469e-003
13580, -1.909627e-001, 2.217592e-001, 1.969470e-003
13581, -1.919351e-001, 2.215249e-001, 1.969472e-003
13582, -1.929075e-001, 2.212907e-001, 1.969473e-003
13583, -1.938799e-001, 2.210564e-001, 1.969474e-003
13584, -1.948523e-001, 2.208221e-001, 1.969475e-003
13585, -1.958247e-001, 2.205879e-001, 1.969477e-003
13586, -1.967971e-001, 2.203536e-001, 1.969478e-003
13587, -1.977695e-001, 2.201194e-001, 1.969481e-003
13588, -1.987419e-001, 2.198851e-001, 1.969490e-003
13589, -1.997150e-001, 2.196503e-001, 1.970155e-003
13590, -2.006896e-001, 2.194141e-001, 1.972488e-003
13591, -2.016650e-001, 2.191784e-001, 1.973876e-003
13592, -2.026377e-001, 2.189456e-001, 1.971204e-003
13593, -2.036089e-001, 2.187136e-001, 1.967839e-003
13594, -2.045797e-001, 2.184813e-001, 1.965137e-003
13595, -2.055508e-001, 2.182483e-001, 1.963502e-003
13596, -2.065227e-001, 2.180146e-001, 1.962747e-003
13597, -2.074964e-001, 2.177817e-001, 1.959792e-003
13598, -2.084730e-001, 2.175537e-001, 1.947186e-003
13599, -2.094621e-001, 2.173331e-001, 1.915975e-003
13600, -2.104643e-001, 2.171209e-001, 1.863021e-003
13601, -2.114612e-001, 2.169124e-001, 1.803257e-003
13602, -2.126242e-001, 2.166202e-001, 1.826288e-003
13603, -2.116033e-001, 2.096547e-001, 2.020642e-003
13604, -2.118718e-001, 2.102341e-001, 2.830891e-003
13605, -2.121794e-001, 2.109504e-001, 3.430257e-003
13606, -2.124586e-001, 2.117169e-001, 3.800673e-003
13607, -2.126945e-001, 2.125026e-001, 3.977056e-003
13608, -2.128619e-001, 2.132883e-001, 3.982361e-003
13609, -2.129173e-001, 2.140716e-001, 3.831222e-003
13610, -2.128835e-001, 2.148388e-001, 3.526604e-003
13611, -2.127995e-001, 2.156456e-001, 2.994180e-003
13612, -2.134796e-001, 2.160432e-001, 2.402451e-003
13613, -2.096194e-001, 2.102410e-001, 2.190781e-003
13614, -2.106156e-001, 2.099426e-001, 2.101364e-003
13615, -2.085225e-001, 2.104174e-001, 2.054270e-003
13616, -2.075372e-001, 2.106163e-001, 1.990488e-003
13617, -2.065708e-001, 2.108304e-001, 1.958489e-003
13618, -2.056062e-001, 2.110539e-001, 1.942944e-003
13619, -2.046403e-001, 2.112827e-001, 1.936218e-003
13620, -2.036736e-001, 2.115142e-001, 1.933718e-003
13621, -2.027066e-001, 2.117465e-001, 1.932692e-003
13622, -2.017398e-001, 2.119797e-001, 1.933071e-003
13623, -2.007738e-001, 2.122137e-001, 1.935345e-003
13624, -1.998082e-001, 2.124487e-001, 1.939523e-003
13625, -1.988426e-001, 2.126838e-001, 1.943815e-003
13626, -1.978764e-001, 2.129184e-001, 1.947089e-003
13627, -1.969098e-001, 2.131524e-001, 1.949110e-003
13628, -1.959429e-001, 2.133860e-001, 1.950195e-003
13629, -1.949758e-001, 2.136192e-001, 1.950722e-003
13630, -1.940086e-001, 2.138524e-001, 1.950957e-003
13631, -1.930413e-001, 2.140855e-001, 1.951053e-003
13632, -1.920740e-001, 2.143185e-001, 1.951086e-003
