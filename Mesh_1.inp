3903, -8.833675e-002, 2.673265e-002, 3.391731e-002
3904, -8.815857e-002, 2.574637e-002, 3.391731e-002
3905, -8.798040e-002, 2.476008e-002, 3.391731e-002
3906, -8.780223e-002, 2.377380e-002, 3.391731e-002
3907, -8.762406e-002, 2.278751e-002, 3.391731e-002
3908, -8.744588e-002, 2.180123e-002, 3.391731e-002
3909, -8.726771e-002, 2.081495e-002, 3.391731e-002
3910, -8.708954e-002, 1.982866e-002, 3.391731e-002
3911, -8.691137e-002, 1.884238e-002, 3.391731e-002
3912, -8.673319e-002, 1.785609e-002, 3.391731e-002
3913, -8.655502e-002, 1.686981e-002, 3.391731e-002
3914, -8.637685e-002, 1.588353e-002, 3.391731e-002
3915, -8.619868e-002, 1.489724e-002, 3.391731e-002
3916, -8.602050e-002, 1.391096e-002, 3.391731e-002
3917, -8.584239e-002, 1.292466e-002, 3.391732e-002
3918, -8.566449e-002, 1.193831e-002, 3.391737e-002
3919, -8.548693e-002, 1.095190e-002, 3.391747e-002
3920, -8.530966e-002, 9.965449e-003, 3.391762e-002
3921, -8.513254e-002, 8.978990e-003, 3.391780e-002
3922, -8.495545e-002, 7.992526e-003, 3.391799e-002
3923, -8.400921e-002, 8.163450e-003, 3.367421e-002
3924, -8.311565e-002, 8.324831e-003, 3.327547e-002
3925, -8.229928e-002, 8.472227e-003, 3.273288e-002
3926, -8.158223e-002, 8.601637e-003, 3.206142e-002
3927, -8.098371e-002, 8.709590e-003, 3.127923e-002
3928, -8.052005e-002, 8.793195e-003, 3.040764e-002
3929, -8.020386e-002, 8.850192e-003, 2.947041e-002
3930, -8.004376e-002, 8.879039e-003, 2.849303e-002
3931, -8.004415e-002, 8.878948e-003, 2.750214e-002
3932, -8.020505e-002, 8.849915e-003, 2.652476e-002
3933, -8.052209e-002, 8.792722e-003, 2.558757e-002
3934, -8.098664e-002, 8.708916e-003, 2.471618e-002
3935, -8.158599e-002, 8.600746e-003, 2.393439e-002
3936, -8.230373e-002, 8.471043e-003, 2.326355e-002
3937, -8.312027e-002, 8.323428e-003, 2.272194e-002
3938, -8.401337e-002, 8.161987e-003, 2.232430e-002
3939, -8.495871e-002, 7.991142e-003, 2.208144e-002
3940, -8.593053e-002, 7.815553e-003, 2.200000e-002
3941, -8.690235e-002, 7.640011e-003, 2.208222e-002
3942, -8.784764e-002, 7.469305e-003, 2.232588e-002
3943, -8.874060e-002, 7.308091e-003, 2.272435e-002
3944, -8.955684e-002, 7.160752e-003, 2.326674e-002
3945, -9.027406e-002, 7.031247e-003, 2.393824e-002
3946, -9.087265e-002, 6.923022e-003, 2.472049e-002
3947, -9.133636e-002, 6.839141e-003, 2.559213e-002
3948, -9.165257e-002, 6.781926e-003, 2.652944e-002
3949, -9.181267e-002, 6.752953e-003, 2.750689e-002
3950, -9.181229e-002, 6.753017e-003, 2.849782e-002
3951, -9.165140e-002, 6.782122e-003, 2.947523e-002
3952, -9.133439e-002, 6.839480e-003, 3.041242e-002
3953, -9.086991e-002, 6.923520e-003, 3.128378e-002
3954, -9.027068e-002, 7.031914e-003, 3.206549e-002
3955, -8.955328e-002, 7.161606e-003, 3.273610e-002
3956, -8.873729e-002, 7.309114e-003, 3.327752e-002
3957, -8.784469e-002, 7.470452e-003, 3.367519e-002
3958, -8.689979e-002, 7.641223e-003, 3.391823e-002
3959, -1.166550e-001, 1.723507e-001, 3.391817e-002
3960, -1.164768e-001, 1.713644e-001, 3.391817e-002
3961, -1.162987e-001, 1.703781e-001, 3.391817e-002
3962, -1.161205e-001, 1.693918e-001, 3.391817e-002
3963, -1.159423e-001, 1.684055e-001, 3.391817e-002
3964, -1.157642e-001, 1.674192e-001, 3.391817e-002
3965, -1.155860e-001, 1.664330e-001, 3.391817e-002
3966, -1.154078e-001, 1.654467e-001, 3.391817e-002
3967, -1.152296e-001, 1.644604e-001, 3.391817e-002
3968, -1.150515e-001, 1.634741e-001, 3.391817e-002
3969, -1.148733e-001, 1.624878e-001, 3.391817e-002
3970, -1.146951e-001, 1.615015e-001, 3.391817e-002
3971, -1.145169e-001, 1.605153e-001, 3.391817e-002
3972, -1.143388e-001, 1.595290e-001, 3.391817e-002
3973, -1.141606e-001, 1.585427e-001, 3.391817e-002
3974, -1.139824e-001, 1.575564e-001, 3.391817e-002
3975, -1.138043e-001, 1.565701e-001, 3.391817e-002
3976, -1.136261e-001, 1.555838e-001, 3.391817e-002
3977, -1.134479e-001, 1.545976e-001, 3.391817e-002
3978, -1.132697e-001, 1.536113e-001, 3.391817e-002
3979, -1.130916e-001, 1.526250e-001, 3.391817e-002
3980, -1.129134e-001, 1.516387e-001, 3.391817e-002
3981, -1.127352e-001, 1.506524e-001, 3.391817e-002
3982, -1.125570e-001, 1.496661e-001, 3.391817e-002
3983, -1.123789e-001, 1.486798e-001, 3.391817e-002
3984, -1.122007e-001, 1.476936e-001, 3.391817e-002
3985, -1.120225e-001, 1.467073e-001, 3.391817e-002
3986, -1.118444e-001, 1.457210e-001, 3.391817e-002
3987, -1.116662e-001, 1.447347e-001, 3.391817e-002
3988, -1.114880e-001, 1.437484e-001, 3.391817e-002
3989, -1.113098e-001, 1.427621e-001, 3.391817e-002
3990, -1.111317e-001, 1.417759e-001, 3.391817e-002
3991, -1.109535e-001, 1.407896e-001, 3.391817e-002
3992, -1.107753e-001, 1.398033e-001, 3.391817e-002
3993, -1.105972e-001, 1.388170e-001, 3.391817e-002
3994, -1.104190e-001, 1.378307e-001, 3.391817e-002
3995, -1.102408e-001, 1.368444e-001, 3.391817e-002
3996, -1.100626e-001, 1.358582e-001, 3.391817e-002
3997, -1.098845e-001, 1.348719e-001, 3.391817e-002
3998, -1.097063e-001, 1.338856e-001, 3.391817e-002
3999, -1.095281e-001, 1.328993e-001, 3.391817e-002
4000, -1.093499e-001, 1.319130e-001, 3.391817e-002
4001, -1.091718e-001, 1.309267e-001, 3.391817e-002
4002, -1.089936e-001, 1.299404e-001, 3.391817e-002
4003, -1.088154e-001, 1.289542e-001, 3.391817e-002
4004, -1.086373e-001, 1.279679e-001, 3.391817e-002
4005, -1.084591e-001, 1.269816e-001, 3.391817e-002
4006, -1.082809e-001, 1.259953e-001, 3.391817e-002
4007, -1.081027e-001, 1.250090e-001, 3.391817e-002
4008, -1.079246e-001, 1.240227e-001, 3.391817e-002
4009, -1.077464e-001, 1.230365e-001, 3.391817e-002
4010, -1.075682e-001, 1.220502e-001, 3.391817e-002
4011, -1.073900e-001, 1.210639e-001, 3.391817e-002
4012, -1.072119e-001, 1.200776e-001, 3.391817e-002
4013, -1.070337e-001, 1.190913e-001, 3.391817e-002
4014, -1.068555e-001, 1.181050e-001, 3.391817e-002
4015, -1.066774e-001, 1.171188e-001, 3.391817e-002
4016, -1.064992e-001, 1.161325e-001, 3.391817e-002
4017, -1.063210e-001, 1.151462e-001, 3.391817e-002
4018, -1.061428e-001, 1.141599e-001, 3.391817e-002
4019, -1.059647e-001, 1.131736e-001, 3.391817e-002
4020, -1.057865e-001, 1.121873e-001, 3.391817e-002
4021, -1.056083e-001, 1.112010e-001, 3.391817e-002
4022, -1.054301e-001, 1.102148e-001, 3.391817e-002
4023, -1.052520e-001, 1.092285e-001, 3.391817e-002
4024, -1.050738e-001, 1.082422e-001, 3.391817e-002
4025, -1.048956e-001, 1.072559e-001, 3.391817e-002
4026, -1.047175e-001, 1.062696e-001, 3.391817e-002
4027, -1.045393e-001, 1.052833e-001, 3.391817e-002
4028, -1.043611e-001, 1.042971e-001, 3.391817e-002
4029, -1.041829e-001, 1.033108e-001, 3.391817e-002
4030, -1.040048e-001, 1.023245e-001, 3.391817e-002
4031, -1.038266e-001, 1.013382e-001, 3.391817e-002
4032, -1.036484e-001, 1.003519e-001, 3.391817e-002
4033, -1.034702e-001, 9.936564e-002, 3.391817e-002
4034, -1.032921e-001, 9.837936e-002, 3.391817e-002
4035, -1.031139e-001, 9.739307e-002, 3.391817e-002
4036, -1.029357e-001, 9.640679e-002, 3.391817e-002
4037, -1.027576e-001, 9.542050e-002, 3.391817e-002
4038, -1.025794e-001, 9.443422e-002, 3.391817e-002
4039, -1.024012e-001, 9.344793e-002, 3.391817e-002
4040, -1.022230e-001, 9.246165e-002, 3.391817e-002
4041, -1.020449e-001, 9.147537e-002, 3.391817e-002
4042, -1.018667e-001, 9.048908e-002, 3.391817e-002
4043, -1.016885e-001, 8.950280e-002, 3.391817e-002
4044, -1.015103e-001, 8.851651e-002, 3.391817e-002
4045, -1.013322e-001, 8.753023e-002, 3.391817e-002
4046, -1.011540e-001, 8.654395e-002, 3.391817e-002
4047, -1.009758e-001, 8.555766e-002, 3.391817e-002
4048, -1.007977e-001, 8.457138e-002, 3.391817e-002
4049, -1.006195e-001, 8.358509e-002, 3.391817e-002
4050, -1.004413e-001, 8.259881e-002, 3.391817e-002
4051, -1.002631e-001, 8.161253e-002, 3.391817e-002
4052, -1.000850e-001, 8.062624e-002, 3.391817e-002
4053, -9.990680e-002, 7.963996e-002, 3.391817e-002
4054, -9.972862e-002, 7.865367e-002, 3.391817e-002
4055, -9.955045e-002, 7.766739e-002, 3.391817e-002
4056, -9.937228e-002, 7.668110e-002, 3.391817e-002
4057, -9.919411e-002, 7.569482e-002, 3.391817e-002
4058, -9.901593e-002, 7.470854e-002, 3.391817e-002
4059, -9.883776e-002, 7.372225e-002, 3.391817e-002
4060, -9.865959e-002, 7.273597e-002, 3.391817e-002
4061, -9.848142e-002, 7.174968e-002, 3.391817e-002
4062, -9.830324e-002, 7.076340e-002, 3.391817e-002
4063, -9.812507e-002, 6.977712e-002, 3.391817e-002
4064, -9.794690e-002, 6.879083e-002, 3.391817e-002
4065, -9.776873e-002, 6.780455e-002, 3.391817e-002
4066, -9.759055e-002, 6.681826e-002, 3.391817e-002
4067, -9.741238e-002, 6.583198e-002, 3.391817e-002
4068, -9.723421e-002, 6.484569e-002, 3.391817e-002
4069, -9.705604e-002, 6.385941e-002, 3.391817e-002
4070, -9.687786e-002, 6.287313e-002, 3.391817e-002
4071, -9.669969e-002, 6.188684e-002, 3.391817e-002
4072, -9.652152e-002, 6.090056e-002, 3.391817e-002
4073, -9.634335e-002, 5.991427e-002, 3.391817e-002
4074, -9.616517e-002, 5.892799e-002, 3.391817e-002
4075, -9.598700e-002, 5.794171e-002, 3.391817e-002
4076, -9.580883e-002, 5.695542e-002, 3.391817e-002
4077, -9.563065e-002, 5.596914e-002, 3.391817e-002
4078, -9.545248e-002, 5.498285e-002, 3.391817e-002
4079, -9.527431e-002, 5.399657e-002, 3.391817e-002
4080, -9.509614e-002, 5.301028e-002, 3.391817e-002
4081, -9.491796e-002, 5.202400e-002, 3.391817e-002
4082, -9.473979e-002, 5.103772e-002, 3.391817e-002
4083, -9.456162e-002, 5.005143e-002, 3.391817e-002
4084, -9.438345e-002, 4.906515e-002, 3.391817e-002
4085, -9.420527e-002, 4.807886e-002, 3.391817e-002
4086, -9.402710e-002, 4.709258e-002, 3.391817e-002
4087, -9.384893e-002, 4.610630e-002, 3.391817e-002
4088, -9.367076e-002, 4.512001e-002, 3.391817e-002
4089, -9.349258e-002, 4.413373e-002, 3.391817e-002
4090, -9.331441e-002, 4.314744e-002, 3.391817e-002
4091, -9.313624e-002, 4.216116e-002, 3.391817e-002
4092, -9.295807e-002, 4.117487e-002, 3.391817e-002
4093, -9.277989e-002, 4.018859e-002, 3.391817e-002
4094, -9.260172e-002, 3.920231e-002, 3.391817e-002
4095, -9.242355e-002, 3.821602e-002, 3.391817e-002
4096, -9.224538e-002, 3.722974e-002, 3.391817e-002
4097, -9.206720e-002, 3.624345e-002, 3.391817e-002
4098, -9.188903e-002, 3.525717e-002, 3.391817e-002
4099, -9.171086e-002, 3.427089e-002, 3.391817e-002
4100, -9.153269e-002, 3.328460e-002, 3.391817e-002
4101, -9.135451e-002, 3.229832e-002, 3.391817e-002
4102, -9.117634e-002, 3.131203e-002, 3.391817e-002
4103, -9.099817e-002, 3.032575e-002, 3.391817e-002
4104, -9.082000e-002, 2.933947e-002, 3.391817e-002
4105, -9.064182e-002, 2.835318e-002, 3.391817e-002
4106, -9.046365e-002, 2.736690e-002, 3.391817e-002
4107, -9.028548e-002, 2.638061e-002, 3.391817e-002
4108, -9.010731e-002, 2.539433e-002, 3.391817e-002
4109, -8.992913e-002, 2.440804e-002, 3.391817e-002
4110, -8.975096e-002, 2.342176e-002, 3.391817e-002
4111, -8.957279e-002, 2.243548e-002, 3.391817e-002
4112, -8.939461e-002, 2.144919e-002, 3.391817e-002
4113, -8.921644e-002, 2.046291e-002, 3.391817e-002
4114, -8.903827e-002, 1.947662e-002, 3.391817e-002
4115, -8.886010e-002, 1.849034e-002, 3.391817e-002
4116, -8.868192e-002, 1.750406e-002, 3.391817e-002
4117, -8.850375e-002, 1.651777e-002, 3.391817e-002
4118, -8.832558e-002, 1.553149e-002, 3.391817e-002
4119, -8.814741e-002, 1.454520e-002, 3.391817e-002
4120, -8.796921e-002, 1.355891e-002, 3.391817e-002
4121, -8.779093e-002, 1.257261e-002, 3.391819e-002
4122, -8.761254e-002, 1.158630e-002, 3.391822e-002
4123, -8.743411e-002, 1.060001e-002, 3.391827e-002
4124, -8.725580e-002, 9.613753e-003, 3.391829e-002
4125, -8.707769e-002, 8.627498e-003, 3.391828e-002
4126, -1.137649e-001, 1.728728e-001, 3.367452e-002
4127, -1.128720e-001, 1.730341e-001, 3.327629e-002
4128, -1.120560e-001, 1.731815e-001, 3.273438e-002
4129, -1.113389e-001, 1.733110e-001, 3.206343e-002
4130, -1.107401e-001, 1.734192e-001, 3.128154e-002
4131, -1.102760e-001, 1.735032e-001, 3.041008e-002
4132, -1.099595e-001, 1.735605e-001, 2.947286e-002
4133, -1.097990e-001, 1.735896e-001, 2.849544e-002
4134, -1.097990e-001, 1.735896e-001, 2.750450e-002
4135, -1.099595e-001, 1.735606e-001, 2.652708e-002
4136, -1.102761e-001, 1.735033e-001, 2.558982e-002
4137, -1.107402e-001, 1.734193e-001, 2.471831e-002
4138, -1.113392e-001, 1.733110e-001, 2.393631e-002
4139, -1.120566e-001, 1.731814e-001, 2.326516e-002
4140, -1.128730e-001, 1.730340e-001, 2.272316e-002
4141, -1.137661e-001, 1.728728e-001, 2.232510e-002
4142, -1.147114e-001, 1.727021e-001, 2.208183e-002
4143, -1.156833e-001, 1.725266e-001, 2.200000e-002
4144, -1.166551e-001, 1.723511e-001, 2.208183e-002
4145, -1.176004e-001, 1.721802e-001, 2.232510e-002
4146, -1.184934e-001, 1.720188e-001, 2.272316e-002
4147, -1.193098e-001, 1.718712e-001, 2.326516e-002
4148, -1.200272e-001, 1.717415e-001, 2.393631e-002
4149, -1.206262e-001, 1.716333e-001, 2.471831e-002
4150, -1.210903e-001, 1.715496e-001, 2.558983e-002
4151, -1.214070e-001, 1.714925e-001, 2.652709e-002
4152, -1.215675e-001, 1.714636e-001, 2.750452e-002
4153, -1.215675e-001, 1.714636e-001, 2.849548e-002
4154, -1.214070e-001, 1.714926e-001, 2.947291e-002
4155, -1.210903e-001, 1.715497e-001, 3.041017e-002
4156, -1.206262e-001, 1.716334e-001, 3.128169e-002
4157, -1.200272e-001, 1.717415e-001, 3.206369e-002
4158, -1.193098e-001, 1.718711e-001, 3.273484e-002
4159, -1.184934e-001, 1.720186e-001, 3.327684e-002
4160, -1.176003e-001, 1.721799e-001, 3.367490e-002
4161, -8.802231e-002, 8.456698e-003, 3.367537e-002
4162, -1.132278e-001, 1.699145e-001, 3.367361e-002
4163, -1.134070e-001, 1.709005e-001, 3.367398e-002
4164, -1.130487e-001, 1.689287e-001, 3.367325e-002
4165, -1.128691e-001, 1.679429e-001, 3.367275e-002
4166, -1.126893e-001, 1.669568e-001, 3.367219e-002
4167, -1.125099e-001, 1.659705e-001, 3.367176e-002
4168, -1.123310e-001, 1.649841e-001, 3.367152e-002
4169, -1.121525e-001, 1.639978e-001, 3.367141e-002
4170, -1.119742e-001, 1.630116e-001, 3.367137e-002
4171, -1.117960e-001, 1.620253e-001, 3.367135e-002
4172, -1.116178e-001, 1.610390e-001, 3.367134e-002
4173, -1.114396e-001, 1.600527e-001, 3.367134e-002
4174, -1.112614e-001, 1.590664e-001, 3.367134e-002
4175, -1.110832e-001, 1.580801e-001, 3.367134e-002
4176, -1.109051e-001, 1.570939e-001, 3.367134e-002
4177, -1.107269e-001, 1.561076e-001, 3.367134e-002
4178, -1.105487e-001, 1.551213e-001, 3.367134e-002
4179, -1.103706e-001, 1.541350e-001, 3.367134e-002
4180, -1.101924e-001, 1.531487e-001, 3.367134e-002
4181, -1.100142e-001, 1.521624e-001, 3.367134e-002
4182, -1.098360e-001, 1.511762e-001, 3.367134e-002
4183, -1.096579e-001, 1.501899e-001, 3.367134e-002
4184, -1.094797e-001, 1.492036e-001, 3.367134e-002
4185, -1.093015e-001, 1.482173e-001, 3.367134e-002
4186, -1.091233e-001, 1.472310e-001, 3.367134e-002
4187, -1.089452e-001, 1.462447e-001, 3.367134e-002
4188, -1.087670e-001, 1.452584e-001, 3.367134e-002
4189, -1.085888e-001, 1.442722e-001, 3.367134e-002
4190, -1.084107e-001, 1.432859e-001, 3.367134e-002
4191, -1.082325e-001, 1.422996e-001, 3.367134e-002
4192, -1.080543e-001, 1.413133e-001, 3.367134e-002
4193, -1.078761e-001, 1.403270e-001, 3.367134e-002
4194, -1.076980e-001, 1.393407e-001, 3.367134e-002
4195, -1.075198e-001, 1.383545e-001, 3.367134e-002
4196, -1.073416e-001, 1.373682e-001, 3.367134e-002
4197, -1.071635e-001, 1.363819e-001, 3.367134e-002
4198, -1.069853e-001, 1.353956e-001, 3.367134e-002
4199, -1.068071e-001, 1.344093e-001, 3.367134e-002
4200, -1.066289e-001, 1.334230e-001, 3.367134e-002
4201, -1.064508e-001, 1.324368e-001, 3.367134e-002
4202, -1.062726e-001, 1.314505e-001, 3.367134e-002
4203, -1.060944e-001, 1.304642e-001, 3.367134e-002
4204, -1.059162e-001, 1.294779e-001, 3.367134e-002
4205, -1.057381e-001, 1.284916e-001, 3.367134e-002
4206, -1.055599e-001, 1.275053e-001, 3.367134e-002
4207, -1.053817e-001, 1.265190e-001, 3.367134e-002
4208, -1.052036e-001, 1.255328e-001, 3.367134e-002
4209, -1.050254e-001, 1.245465e-001, 3.367134e-002
4210, -1.048472e-001, 1.235602e-001, 3.367134e-002
4211, -1.046690e-001, 1.225739e-001, 3.367134e-002
4212, -1.044909e-001, 1.215876e-001, 3.367134e-002
4213, -1.043127e-001, 1.206013e-001, 3.367134e-002
4214, -1.041345e-001, 1.196151e-001, 3.367134e-002
4215, -1.039563e-001, 1.186288e-001, 3.367134e-002
4216, -1.037782e-001, 1.176425e-001, 3.367134e-002
4217, -1.036000e-001, 1.166562e-001, 3.367134e-002
4218, -1.034218e-001, 1.156699e-001, 3.367134e-002
4219, -1.032437e-001, 1.146836e-001, 3.367134e-002
4220, -1.030655e-001, 1.136974e-001, 3.367134e-002
4221, -1.028873e-001, 1.127111e-001, 3.367134e-002
4222, -1.027091e-001, 1.117248e-001, 3.367134e-002
4223, -1.025310e-001, 1.107385e-001, 3.367134e-002
4224, -1.023528e-001, 1.097522e-001, 3.367134e-002
4225, -1.021746e-001, 1.087659e-001, 3.367134e-002
4226, -1.019964e-001, 1.077797e-001, 3.367134e-002
4227, -1.018183e-001, 1.067934e-001, 3.367134e-002
4228, -1.016401e-001, 1.058071e-001, 3.367134e-002
4229, -1.014619e-001, 1.048208e-001, 3.367134e-002
4230, -1.012838e-001, 1.038345e-001, 3.367134e-002
4231, -1.011056e-001, 1.028482e-001, 3.367134e-002
4232, -1.009274e-001, 1.018619e-001, 3.367134e-002
4233, -1.007492e-001, 1.008757e-001, 3.367134e-002
4234, -1.005711e-001, 9.988938e-002, 3.367134e-002
4235, -1.003929e-001, 9.890309e-002, 3.367134e-002
4236, -1.002147e-001, 9.791681e-002, 3.367134e-002
4237, -1.000365e-001, 9.693052e-002, 3.367134e-002
4238, -9.985838e-002, 9.594424e-002, 3.367134e-002
4239, -9.968020e-002, 9.495796e-002, 3.367134e-002
4240, -9.950203e-002, 9.397167e-002, 3.367134e-002
4241, -9.932386e-002, 9.298539e-002, 3.367134e-002
4242, -9.914569e-002, 9.199910e-002, 3.367134e-002
4243, -9.896751e-002, 9.101282e-002, 3.367134e-002
4244, -9.878934e-002, 9.002654e-002, 3.367134e-002
4245, -9.861117e-002, 8.904025e-002, 3.367134e-002
4246, -9.843299e-002, 8.805397e-002, 3.367134e-002
4247, -9.825482e-002, 8.706768e-002, 3.367134e-002
4248, -9.807665e-002, 8.608140e-002, 3.367134e-002
4249, -9.789848e-002, 8.509512e-002, 3.367134e-002
4250, -9.772030e-002, 8.410883e-002, 3.367134e-002
4251, -9.754213e-002, 8.312255e-002, 3.367134e-002
4252, -9.736396e-002, 8.213626e-002, 3.367134e-002
4253, -9.718579e-002, 8.114998e-002, 3.367134e-002
4254, -9.700761e-002, 8.016369e-002, 3.367134e-002
4255, -9.682944e-002, 7.917741e-002, 3.367134e-002
4256, -9.665127e-002, 7.819113e-002, 3.367134e-002
4257, -9.647310e-002, 7.720484e-002, 3.367134e-002
4258, -9.629492e-002, 7.621856e-002, 3.367134e-002
4259, -9.611675e-002, 7.523227e-002, 3.367134e-002
4260, -9.593858e-002, 7.424599e-002, 3.367134e-002
4261, -9.576041e-002, 7.325971e-002, 3.367134e-002
4262, -9.558223e-002, 7.227342e-002, 3.367134e-002
4263, -9.540406e-002, 7.128714e-002, 3.367134e-002
4264, -9.522589e-002, 7.030085e-002, 3.367134e-002
4265, -9.504772e-002, 6.931457e-002, 3.367134e-002
4266, -9.486954e-002, 6.832828e-002, 3.367134e-002
4267, -9.469137e-002, 6.734200e-002, 3.367134e-002
4268, -9.451320e-002, 6.635572e-002, 3.367134e-002
4269, -9.433503e-002, 6.536943e-002, 3.367134e-002
4270, -9.415685e-002, 6.438315e-002, 3.367134e-002
4271, -9.397868e-002, 6.339686e-002, 3.367134e-002
4272, -9.380051e-002, 6.241058e-002, 3.367134e-002
4273, -9.362234e-002, 6.142430e-002, 3.367134e-002
4274, -9.344416e-002, 6.043801e-002, 3.367134e-002
4275, -9.326599e-002, 5.945173e-002, 3.367134e-002
4276, -9.308782e-002, 5.846544e-002, 3.367134e-002
4277, -9.290965e-002, 5.747916e-002, 3.367134e-002
4278, -9.273147e-002, 5.649287e-002, 3.367134e-002
4279, -9.255330e-002, 5.550659e-002, 3.367134e-002
4280, -9.237513e-002, 5.452031e-002, 3.367134e-002
4281, -9.219695e-002, 5.353402e-002, 3.367134e-002
4282, -9.201878e-002, 5.254774e-002, 3.367134e-002
4283, -9.184061e-002, 5.156145e-002, 3.367134e-002
4284, -9.166244e-002, 5.057517e-002, 3.367134e-002
4285, -9.148426e-002, 4.958889e-002, 3.367134e-002
4286, -9.130609e-002, 4.860260e-002, 3.367134e-002
4287, -9.112792e-002, 4.761632e-002, 3.367134e-002
4288, -9.094975e-002, 4.663003e-002, 3.367134e-002
4289, -9.077157e-002, 4.564375e-002, 3.367134e-002
4290, -9.059340e-002, 4.465747e-002, 3.367134e-002
4291, -9.041523e-002, 4.367118e-002, 3.367134e-002
4292, -9.023706e-002, 4.268490e-002, 3.367134e-002
4293, -9.005888e-002, 4.169861e-002, 3.367134e-002
4294, -8.988071e-002, 4.071233e-002, 3.367134e-002
4295, -8.970254e-002, 3.972604e-002, 3.367134e-002
4296, -8.952437e-002, 3.873976e-002, 3.367134e-002
4297, -8.934619e-002, 3.775348e-002, 3.367134e-002
4298, -8.916802e-002, 3.676719e-002, 3.367134e-002
4299, -8.898985e-002, 3.578091e-002, 3.367134e-002
4300, -8.881168e-002, 3.479462e-002, 3.367134e-002
4301, -8.863350e-002, 3.380834e-002, 3.367134e-002
4302, -8.845533e-002, 3.282206e-002, 3.367134e-002
4303, -8.827716e-002, 3.183577e-002, 3.367134e-002
4304, -8.809899e-002, 3.084949e-002, 3.367134e-002
4305, -8.792081e-002, 2.986320e-002, 3.367134e-002
4306, -8.774264e-002, 2.887692e-002, 3.367134e-002
4307, -8.756447e-002, 2.789063e-002, 3.367134e-002
4308, -8.738630e-002, 2.690435e-002, 3.367134e-002
4309, -8.720812e-002, 2.591807e-002, 3.367134e-002
4310, -8.702995e-002, 2.493178e-002, 3.367134e-002
4311, -8.685178e-002, 2.394550e-002, 3.367134e-002
4312, -8.667361e-002, 2.295921e-002, 3.367134e-002
4313, -8.649543e-002, 2.197293e-002, 3.367134e-002
4314, -8.631726e-002, 2.098665e-002, 3.367134e-002
4315, -8.613909e-002, 2.000036e-002, 3.367134e-002
4316, -8.596092e-002, 1.901408e-002, 3.367134e-002
4317, -8.578274e-002, 1.802779e-002, 3.367134e-002
4318, -8.560457e-002, 1.704151e-002, 3.367134e-002
4319, -8.542640e-002, 1.605522e-002, 3.367134e-002
4320, -8.524823e-002, 1.506894e-002, 3.367134e-002
4321, -8.507009e-002, 1.408264e-002, 3.367136e-002
4322, -8.489217e-002, 1.309629e-002, 3.367144e-002
4323, -8.471476e-002, 1.210981e-002, 3.367172e-002
4324, -8.453798e-002, 1.112322e-002, 3.367221e-002
4325, -8.436162e-002, 1.013661e-002, 3.367284e-002
4326, -8.418541e-002, 9.150030e-003, 3.367353e-002
4327, -8.329121e-002, 9.311447e-003, 3.327404e-002
4328, -8.247470e-002, 9.458723e-003, 3.273074e-002
4329, -8.175801e-002, 9.587873e-003, 3.205887e-002
4330, -8.116007e-002, 9.695550e-003, 3.127657e-002
4331, -8.069696e-002, 9.778902e-003, 3.040505e-002
4332, -8.038127e-002, 9.835677e-003, 2.946800e-002
4333, -8.022157e-002, 9.864359e-003, 2.849080e-002
4334, -8.022231e-002, 9.864159e-003, 2.750005e-002
4335, -8.038354e-002, 9.835065e-003, 2.652275e-002
4336, -8.070093e-002, 9.777843e-003, 2.558562e-002
4337, -8.116585e-002, 9.694024e-003, 2.471429e-002
4338, -8.176558e-002, 9.585835e-003, 2.393264e-002
4339, -8.248351e-002, 9.456074e-003, 2.326214e-002
4340, -8.330013e-002, 9.308390e-003, 2.272091e-002
4341, -8.419327e-002, 9.146892e-003, 2.232363e-002
4342, -8.513862e-002, 8.976007e-003, 2.208111e-002
4343, -8.611045e-002, 8.800404e-003, 2.200000e-002
4344, -8.708226e-002, 8.624872e-003, 2.208255e-002
4345, -8.802754e-002, 8.454201e-003, 2.232655e-002
4346, -8.892047e-002, 8.293044e-003, 2.272538e-002
4347, -8.973664e-002, 8.145777e-003, 2.326816e-002
4348, -9.045364e-002, 8.016337e-003, 2.393999e-002
4349, -9.105185e-002, 7.908136e-003, 2.472236e-002
4350, -9.151518e-002, 7.824267e-003, 2.559407e-002
4351, -9.183104e-002, 7.767071e-003, 2.653140e-002
4352, -9.199081e-002, 7.738131e-003, 2.750886e-002
4353, -9.199010e-002, 7.738250e-003, 2.849979e-002
4354, -9.182890e-002, 7.767449e-003, 2.947717e-002
4355, -9.151157e-002, 7.824948e-003, 3.041430e-002
4356, -9.104680e-002, 7.909166e-003, 3.128554e-002
4357, -9.044741e-002, 8.017763e-003, 3.206696e-002
4358, -8.973025e-002, 8.147644e-003, 3.273699e-002
4359, -8.891463e-002, 8.295274e-003, 3.327795e-002
4360, -1.174222e-001, 1.711936e-001, 3.367490e-002
4361, -1.172440e-001, 1.702073e-001, 3.367490e-002
4362, -1.170658e-001, 1.692210e-001, 3.367490e-002
4363, -1.168877e-001, 1.682348e-001, 3.367490e-002
4364, -1.167095e-001, 1.672485e-001, 3.367490e-002
4365, -1.165313e-001, 1.662622e-001, 3.367490e-002
4366, -1.163531e-001, 1.652759e-001, 3.367490e-002
4367, -1.161750e-001, 1.642896e-001, 3.367490e-002
4368, -1.159968e-001, 1.633033e-001, 3.367490e-002
4369, -1.158186e-001, 1.623171e-001, 3.367490e-002
4370, -1.156404e-001, 1.613308e-001, 3.367490e-002
4371, -1.154623e-001, 1.603445e-001, 3.367490e-002
4372, -1.152841e-001, 1.593582e-001, 3.367490e-002
4373, -1.151059e-001, 1.583719e-001, 3.367490e-002
4374, -1.149278e-001, 1.573856e-001, 3.367490e-002
4375, -1.147496e-001, 1.563993e-001, 3.367490e-002
4376, -1.145714e-001, 1.554131e-001, 3.367490e-002
4377, -1.143932e-001, 1.544268e-001, 3.367490e-002
4378, -1.142151e-001, 1.534405e-001, 3.367490e-002
4379, -1.140369e-001, 1.524542e-001, 3.367490e-002
4380, -1.138587e-001, 1.514679e-001, 3.367490e-002
4381, -1.136805e-001, 1.504816e-001, 3.367490e-002
4382, -1.135024e-001, 1.494954e-001, 3.367490e-002
4383, -1.133242e-001, 1.485091e-001, 3.367490e-002
4384, -1.131460e-001, 1.475228e-001, 3.367490e-002
4385, -1.129679e-001, 1.465365e-001, 3.367490e-002
4386, -1.127897e-001, 1.455502e-001, 3.367490e-002
4387, -1.126115e-001, 1.445639e-001, 3.367490e-002
4388, -1.124333e-001, 1.435777e-001, 3.367490e-002
4389, -1.122552e-001, 1.425914e-001, 3.367490e-002
4390, -1.120770e-001, 1.416051e-001, 3.367490e-002
4391, -1.118988e-001, 1.406188e-001, 3.367490e-002
4392, -1.117207e-001, 1.396325e-001, 3.367490e-002
4393, -1.115425e-001, 1.386462e-001, 3.367490e-002
4394, -1.113643e-001, 1.376599e-001, 3.367490e-002
4395, -1.111861e-001, 1.366737e-001, 3.367490e-002
4396, -1.110080e-001, 1.356874e-001, 3.367490e-002
4397, -1.108298e-001, 1.347011e-001, 3.367490e-002
4398, -1.106516e-001, 1.337148e-001, 3.367490e-002
4399, -1.104734e-001, 1.327285e-001, 3.367490e-002
4400, -1.102953e-001, 1.317422e-001, 3.367490e-002
4401, -1.101171e-001, 1.307560e-001, 3.367490e-002
4402, -1.099389e-001, 1.297697e-001, 3.367490e-002
4403, -1.097608e-001, 1.287834e-001, 3.367490e-002
4404, -1.095826e-001, 1.277971e-001, 3.367490e-002
4405, -1.094044e-001, 1.268108e-001, 3.367490e-002
4406, -1.092262e-001, 1.258245e-001, 3.367490e-002
4407, -1.090481e-001, 1.248383e-001, 3.367490e-002
4408, -1.088699e-001, 1.238520e-001, 3.367490e-002
4409, -1.086917e-001, 1.228657e-001, 3.367490e-002
4410, -1.085135e-001, 1.218794e-001, 3.367490e-002
4411, -1.083354e-001, 1.208931e-001, 3.367490e-002
4412, -1.081572e-001, 1.199068e-001, 3.367490e-002
4413, -1.079790e-001, 1.189205e-001, 3.367490e-002
4414, -1.078009e-001, 1.179343e-001, 3.367490e-002
4415, -1.076227e-001, 1.169480e-001, 3.367490e-002
4416, -1.074445e-001, 1.159617e-001, 3.367490e-002
4417, -1.072663e-001, 1.149754e-001, 3.367490e-002
4418, -1.070882e-001, 1.139891e-001, 3.367490e-002
4419, -1.069100e-001, 1.130028e-001, 3.367490e-002
4420, -1.067318e-001, 1.120166e-001, 3.367490e-002
4421, -1.065536e-001, 1.110303e-001, 3.367490e-002
4422, -1.063755e-001, 1.100440e-001, 3.367490e-002
4423, -1.061973e-001, 1.090577e-001, 3.367490e-002
4424, -1.060191e-001, 1.080714e-001, 3.367490e-002
4425, -1.058410e-001, 1.070851e-001, 3.367490e-002
4426, -1.056628e-001, 1.060989e-001, 3.367490e-002
4427, -1.054846e-001, 1.051126e-001, 3.367490e-002
4428, -1.053064e-001, 1.041263e-001, 3.367490e-002
4429, -1.051283e-001, 1.031400e-001, 3.367490e-002
4430, -1.049501e-001, 1.021537e-001, 3.367490e-002
4431, -1.047719e-001, 1.011674e-001, 3.367490e-002
4432, -1.045937e-001, 1.001812e-001, 3.367490e-002
4433, -1.044156e-001, 9.919487e-002, 3.367490e-002
4434, -1.042374e-001, 9.820858e-002, 3.367490e-002
4435, -1.040592e-001, 9.722230e-002, 3.367490e-002
4436, -1.038811e-001, 9.623601e-002, 3.367490e-002
4437, -1.037029e-001, 9.524973e-002, 3.367490e-002
4438, -1.035247e-001, 9.426345e-002, 3.367490e-002
4439, -1.033465e-001, 9.327716e-002, 3.367490e-002
4440, -1.031684e-001, 9.229088e-002, 3.367490e-002
4441, -1.029902e-001, 9.130459e-002, 3.367490e-002
4442, -1.028120e-001, 9.031831e-002, 3.367490e-002
4443, -1.026339e-001, 8.933202e-002, 3.367490e-002
4444, -1.024557e-001, 8.834574e-002, 3.367490e-002
4445, -1.022775e-001, 8.735946e-002, 3.367490e-002
4446, -1.020993e-001, 8.637317e-002, 3.367490e-002
4447, -1.019212e-001, 8.538689e-002, 3.367490e-002
4448, -1.017430e-001, 8.440060e-002, 3.367490e-002
4449, -1.015648e-001, 8.341432e-002, 3.367490e-002
4450, -1.013866e-001, 8.242804e-002, 3.367490e-002
4451, -1.012085e-001, 8.144175e-002, 3.367490e-002
4452, -1.010303e-001, 8.045547e-002, 3.367490e-002
4453, -1.008521e-001, 7.946918e-002, 3.367490e-002
4454, -1.006740e-001, 7.848290e-002, 3.367490e-002
4455, -1.004958e-001, 7.749661e-002, 3.367490e-002
4456, -1.003176e-001, 7.651033e-002, 3.367490e-002
4457, -1.001394e-001, 7.552405e-002, 3.367490e-002
4458, -9.996126e-002, 7.453776e-002, 3.367490e-002
4459, -9.978309e-002, 7.355148e-002, 3.367490e-002
4460, -9.960492e-002, 7.256519e-002, 3.367490e-002
4461, -9.942674e-002, 7.157891e-002, 3.367490e-002
4462, -9.924857e-002, 7.059263e-002, 3.367490e-002
4463, -9.907040e-002, 6.960634e-002, 3.367490e-002
4464, -9.889223e-002, 6.862006e-002, 3.367490e-002
4465, -9.871405e-002, 6.763377e-002, 3.367490e-002
4466, -9.853588e-002, 6.664749e-002, 3.367490e-002
4467, -9.835771e-002, 6.566120e-002, 3.367490e-002
4468, -9.817954e-002, 6.467492e-002, 3.367490e-002
4469, -9.800136e-002, 6.368864e-002, 3.367490e-002
4470, -9.782319e-002, 6.270235e-002, 3.367490e-002
4471, -9.764502e-002, 6.171607e-002, 3.367490e-002
4472, -9.746685e-002, 6.072978e-002, 3.367490e-002
4473, -9.728867e-002, 5.974350e-002, 3.367490e-002
4474, -9.711050e-002, 5.875722e-002, 3.367490e-002
4475, -9.693233e-002, 5.777093e-002, 3.367490e-002
4476, -9.675416e-002, 5.678465e-002, 3.367490e-002
4477, -9.657598e-002, 5.579836e-002, 3.367490e-002
4478, -9.639781e-002, 5.481208e-002, 3.367490e-002
4479, -9.621964e-002, 5.382580e-002, 3.367490e-002
4480, -9.604147e-002, 5.283951e-002, 3.367490e-002
4481, -9.586329e-002, 5.185323e-002, 3.367490e-002
4482, -9.568512e-002, 5.086694e-002, 3.367490e-002
4483, -9.550695e-002, 4.988066e-002, 3.367490e-002
4484, -9.532877e-002, 4.889437e-002, 3.367490e-002
4485, -9.515060e-002, 4.790809e-002, 3.367490e-002
4486, -9.497243e-002, 4.692181e-002, 3.367490e-002
4487, -9.479426e-002, 4.593552e-002, 3.367490e-002
4488, -9.461608e-002, 4.494924e-002, 3.367490e-002
4489, -9.443791e-002, 4.396295e-002, 3.367490e-002
4490, -9.425974e-002, 4.297667e-002, 3.367490e-002
4491, -9.408157e-002, 4.199039e-002, 3.367490e-002
4492, -9.390339e-002, 4.100410e-002, 3.367490e-002
4493, -9.372522e-002, 4.001782e-002, 3.367490e-002
4494, -9.354705e-002, 3.903153e-002, 3.367490e-002
4495, -9.336888e-002, 3.804525e-002, 3.367490e-002
4496, -9.319070e-002, 3.705896e-002, 3.367490e-002
4497, -9.301253e-002, 3.607268e-002, 3.367490e-002
4498, -9.283436e-002, 3.508640e-002, 3.367490e-002
4499, -9.265619e-002, 3.410011e-002, 3.367490e-002
4500, -9.247801e-002, 3.311383e-002, 3.367490e-002
4501, -9.229984e-002, 3.212754e-002, 3.367490e-002
4502, -9.212167e-002, 3.114126e-002, 3.367490e-002
4503, -9.194350e-002, 3.015498e-002, 3.367490e-002
4504, -9.176532e-002, 2.916869e-002, 3.367490e-002
4505, -9.158715e-002, 2.818241e-002, 3.367490e-002
4506, -9.140898e-002, 2.719612e-002, 3.367490e-002
4507, -9.123081e-002, 2.620984e-002, 3.367490e-002
4508, -9.105263e-002, 2.522355e-002, 3.367490e-002
4509, -9.087446e-002, 2.423727e-002, 3.367490e-002
4510, -9.069629e-002, 2.325099e-002, 3.367490e-002
4511, -9.051812e-002, 2.226470e-002, 3.367490e-002
4512, -9.033994e-002, 2.127842e-002, 3.367490e-002
4513, -9.016177e-002, 2.029213e-002, 3.367490e-002
4514, -8.998360e-002, 1.930585e-002, 3.367490e-002
4515, -8.980543e-002, 1.831957e-002, 3.367490e-002
4516, -8.962725e-002, 1.733328e-002, 3.367490e-002
4517, -8.944908e-002, 1.634700e-002, 3.367490e-002
4518, -8.927091e-002, 1.536071e-002, 3.367490e-002
4519, -8.909272e-002, 1.437442e-002, 3.367491e-002
4520, -8.891446e-002, 1.338810e-002, 3.367493e-002
4521, -8.873602e-002, 1.240174e-002, 3.367502e-002
4522, -8.855738e-002, 1.141538e-002, 3.367517e-002
4523, -8.837874e-002, 1.042909e-002, 3.367533e-002
4524, -8.820036e-002, 9.442882e-003, 3.367541e-002
4525, -1.135861e-001, 1.718866e-001, 3.367429e-002
4526, -1.126931e-001, 1.720479e-001, 3.327591e-002
4527, -1.118773e-001, 1.721953e-001, 3.273398e-002
4528, -1.111605e-001, 1.723249e-001, 3.206313e-002
4529, -1.105618e-001, 1.724333e-001, 3.128130e-002
4530, -1.100979e-001, 1.725176e-001, 3.040988e-002
4531, -1.097814e-001, 1.725752e-001, 2.947268e-002
4532, -1.096210e-001, 1.726044e-001, 2.849531e-002
4533, -1.096210e-001, 1.726045e-001, 2.750442e-002
4534, -1.097815e-001, 1.725754e-001, 2.652704e-002
4535, -1.100981e-001, 1.725179e-001, 2.558981e-002
4536, -1.105622e-001, 1.724336e-001, 2.471830e-002
4537, -1.111611e-001, 1.723251e-001, 2.393631e-002
4538, -1.118785e-001, 1.721955e-001, 2.326516e-002
4539, -1.126949e-001, 1.720483e-001, 2.272316e-002
4540, -1.135880e-001, 1.718874e-001, 2.232510e-002
4541, -1.145334e-001, 1.717169e-001, 2.208183e-002
4542, -1.155053e-001, 1.715415e-001, 2.200000e-002
4543, -1.164771e-001, 1.713659e-001, 2.208183e-002
4544, -1.174224e-001, 1.711949e-001, 2.232510e-002
4545, -1.183154e-001, 1.710332e-001, 2.272316e-002
4546, -1.191317e-001, 1.708854e-001, 2.326516e-002
4547, -1.198491e-001, 1.707556e-001, 2.393631e-002
4548, -1.204481e-001, 1.706475e-001, 2.471831e-002
4549, -1.209123e-001, 1.705640e-001, 2.558983e-002
4550, -1.212290e-001, 1.705072e-001, 2.652709e-002
4551, -1.213895e-001, 1.704785e-001, 2.750453e-002
4552, -1.213896e-001, 1.704785e-001, 2.849548e-002
4553, -1.212290e-001, 1.705073e-001, 2.947292e-002
4554, -1.209123e-001, 1.705641e-001, 3.041017e-002
4555, -1.204481e-001, 1.706475e-001, 3.128169e-002
4556, -1.198491e-001, 1.707554e-001, 3.206369e-002
4557, -1.191316e-001, 1.708849e-001, 3.273484e-002
4558, -1.183152e-001, 1.710323e-001, 3.327684e-002
4559, -1.117933e-001, 1.671195e-001, 3.327082e-002
4560, -1.119744e-001, 1.681058e-001, 3.327240e-002
4561, -1.123347e-001, 1.700763e-001, 3.327471e-002
4562, -1.125141e-001, 1.710620e-001, 3.327543e-002
4563, -1.121550e-001, 1.690911e-001, 3.327378e-002
4564, -1.116128e-001, 1.661329e-001, 3.326962e-002
4565, -1.114334e-001, 1.651464e-001, 3.326899e-002
4566, -1.112547e-001, 1.641601e-001, 3.326872e-002
4567, -1.110764e-001, 1.631738e-001, 3.326863e-002
4568, -1.108981e-001, 1.621875e-001, 3.326859e-002
4569, -1.107199e-001, 1.612012e-001, 3.326858e-002
4570, -1.105418e-001, 1.602149e-001, 3.326858e-002
4571, -1.103636e-001, 1.592286e-001, 3.326858e-002
4572, -1.101854e-001, 1.582423e-001, 3.326858e-002
4573, -1.100072e-001, 1.572561e-001, 3.326858e-002
4574, -1.098291e-001, 1.562698e-001, 3.326858e-002
4575, -1.096509e-001, 1.552835e-001, 3.326858e-002
4576, -1.094727e-001, 1.542972e-001, 3.326858e-002
4577, -1.092946e-001, 1.533109e-001, 3.326858e-002
4578, -1.091164e-001, 1.523246e-001, 3.326858e-002
4579, -1.089382e-001, 1.513383e-001, 3.326858e-002
4580, -1.087600e-001, 1.503521e-001, 3.326858e-002
4581, -1.085819e-001, 1.493658e-001, 3.326858e-002
4582, -1.084037e-001, 1.483795e-001, 3.326858e-002
4583, -1.082255e-001, 1.473932e-001, 3.326858e-002
4584, -1.080473e-001, 1.464069e-001, 3.326858e-002
4585, -1.078692e-001, 1.454206e-001, 3.326858e-002
4586, -1.076910e-001, 1.444344e-001, 3.326858e-002
4587, -1.075128e-001, 1.434481e-001, 3.326858e-002
4588, -1.073347e-001, 1.424618e-001, 3.326858e-002
4589, -1.071565e-001, 1.414755e-001, 3.326858e-002
4590, -1.069783e-001, 1.404892e-001, 3.326858e-002
4591, -1.068001e-001, 1.395029e-001, 3.326858e-002
4592, -1.066220e-001, 1.385167e-001, 3.326858e-002
4593, -1.064438e-001, 1.375304e-001, 3.326858e-002
4594, -1.062656e-001, 1.365441e-001, 3.326858e-002
4595, -1.060874e-001, 1.355578e-001, 3.326858e-002
4596, -1.059093e-001, 1.345715e-001, 3.326858e-002
4597, -1.057311e-001, 1.335852e-001, 3.326858e-002
4598, -1.055529e-001, 1.325989e-001, 3.326858e-002
4599, -1.053748e-001, 1.316127e-001, 3.326858e-002
4600, -1.051966e-001, 1.306264e-001, 3.326858e-002
4601, -1.050184e-001, 1.296401e-001, 3.326858e-002
4602, -1.048402e-001, 1.286538e-001, 3.326858e-002
4603, -1.046621e-001, 1.276675e-001, 3.326858e-002
4604, -1.044839e-001, 1.266812e-001, 3.326858e-002
4605, -1.043057e-001, 1.256950e-001, 3.326858e-002
4606, -1.041275e-001, 1.247087e-001, 3.326858e-002
4607, -1.039494e-001, 1.237224e-001, 3.326858e-002
4608, -1.037712e-001, 1.227361e-001, 3.326858e-002
4609, -1.035930e-001, 1.217498e-001, 3.326858e-002
4610, -1.034149e-001, 1.207635e-001, 3.326858e-002
4611, -1.032367e-001, 1.197773e-001, 3.326858e-002
4612, -1.030585e-001, 1.187910e-001, 3.326858e-002
4613, -1.028803e-001, 1.178047e-001, 3.326858e-002
4614, -1.027022e-001, 1.168184e-001, 3.326858e-002
4615, -1.025240e-001, 1.158321e-001, 3.326858e-002
4616, -1.023458e-001, 1.148458e-001, 3.326858e-002
4617, -1.021676e-001, 1.138595e-001, 3.326858e-002
4618, -1.019895e-001, 1.128733e-001, 3.326858e-002
4619, -1.018113e-001, 1.118870e-001, 3.326858e-002
4620, -1.016331e-001, 1.109007e-001, 3.326858e-002
4621, -1.014550e-001, 1.099144e-001, 3.326858e-002
4622, -1.012768e-001, 1.089281e-001, 3.326858e-002
4623, -1.010986e-001, 1.079418e-001, 3.326858e-002
4624, -1.009204e-001, 1.069556e-001, 3.326858e-002
4625, -1.007423e-001, 1.059693e-001, 3.326858e-002
4626, -1.005641e-001, 1.049830e-001, 3.326858e-002
4627, -1.003859e-001, 1.039967e-001, 3.326858e-002
4628, -1.002078e-001, 1.030104e-001, 3.326858e-002
4629, -1.000296e-001, 1.020241e-001, 3.326858e-002
4630, -9.985141e-002, 1.010379e-001, 3.326858e-002
4631, -9.967323e-002, 1.000516e-001, 3.326858e-002
4632, -9.949506e-002, 9.906529e-002, 3.326858e-002
4633, -9.931689e-002, 9.807900e-002, 3.326858e-002
4634, -9.913872e-002, 9.709272e-002, 3.326858e-002
4635, -9.896054e-002, 9.610643e-002, 3.326858e-002
4636, -9.878237e-002, 9.512015e-002, 3.326858e-002
4637, -9.860420e-002, 9.413387e-002, 3.326858e-002
4638, -9.842603e-002, 9.314758e-002, 3.326858e-002
4639, -9.824785e-002, 9.216130e-002, 3.326858e-002
4640, -9.806968e-002, 9.117501e-002, 3.326858e-002
4641, -9.789151e-002, 9.018873e-002, 3.326858e-002
4642, -9.771333e-002, 8.920245e-002, 3.326858e-002
4643, -9.753516e-002, 8.821616e-002, 3.326858e-002
4644, -9.735699e-002, 8.722988e-002, 3.326858e-002
4645, -9.717882e-002, 8.624359e-002, 3.326858e-002
4646, -9.700064e-002, 8.525731e-002, 3.326858e-002
4647, -9.682247e-002, 8.427102e-002, 3.326858e-002
4648, -9.664430e-002, 8.328474e-002, 3.326858e-002
4649, -9.646613e-002, 8.229846e-002, 3.326858e-002
4650, -9.628795e-002, 8.131217e-002, 3.326858e-002
4651, -9.610978e-002, 8.032589e-002, 3.326858e-002
4652, -9.593161e-002, 7.933960e-002, 3.326858e-002
4653, -9.575344e-002, 7.835332e-002, 3.326858e-002
4654, -9.557526e-002, 7.736704e-002, 3.326858e-002
4655, -9.539709e-002, 7.638075e-002, 3.326858e-002
4656, -9.521892e-002, 7.539447e-002, 3.326858e-002
4657, -9.504075e-002, 7.440818e-002, 3.326858e-002
4658, -9.486257e-002, 7.342190e-002, 3.326858e-002
4659, -9.468440e-002, 7.243562e-002, 3.326858e-002
4660, -9.450623e-002, 7.144933e-002, 3.326858e-002
4661, -9.432806e-002, 7.046305e-002, 3.326858e-002
4662, -9.414988e-002, 6.947676e-002, 3.326858e-002
4663, -9.397171e-002, 6.849048e-002, 3.326858e-002
4664, -9.379354e-002, 6.750419e-002, 3.326858e-002
4665, -9.361537e-002, 6.651791e-002, 3.326858e-002
4666, -9.343719e-002, 6.553163e-002, 3.326858e-002
4667, -9.325902e-002, 6.454534e-002, 3.326858e-002
4668, -9.308085e-002, 6.355906e-002, 3.326858e-002
4669, -9.290268e-002, 6.257277e-002, 3.326858e-002
4670, -9.272450e-002, 6.158649e-002, 3.326858e-002
4671, -9.254633e-002, 6.060021e-002, 3.326858e-002
4672, -9.236816e-002, 5.961392e-002, 3.326858e-002
4673, -9.218999e-002, 5.862764e-002, 3.326858e-002
4674, -9.201181e-002, 5.764135e-002, 3.326858e-002
4675, -9.183364e-002, 5.665507e-002, 3.326858e-002
4676, -9.165547e-002, 5.566878e-002, 3.326858e-002
4677, -9.147730e-002, 5.468250e-002, 3.326858e-002
4678, -9.129912e-002, 5.369622e-002, 3.326858e-002
4679, -9.112095e-002, 5.270993e-002, 3.326858e-002
4680, -9.094278e-002, 5.172365e-002, 3.326858e-002
4681, -9.076460e-002, 5.073736e-002, 3.326858e-002
4682, -9.058643e-002, 4.975108e-002, 3.326858e-002
4683, -9.040826e-002, 4.876480e-002, 3.326858e-002
4684, -9.023009e-002, 4.777851e-002, 3.326858e-002
4685, -9.005191e-002, 4.679223e-002, 3.326858e-002
4686, -8.987374e-002, 4.580594e-002, 3.326858e-002
4687, -8.969557e-002, 4.481966e-002, 3.326858e-002
4688, -8.951740e-002, 4.383337e-002, 3.326858e-002
4689, -8.933922e-002, 4.284709e-002, 3.326858e-002
4690, -8.916105e-002, 4.186081e-002, 3.326858e-002
4691, -8.898288e-002, 4.087452e-002, 3.326858e-002
4692, -8.880471e-002, 3.988824e-002, 3.326858e-002
4693, -8.862653e-002, 3.890195e-002, 3.326858e-002
4694, -8.844836e-002, 3.791567e-002, 3.326858e-002
4695, -8.827019e-002, 3.692939e-002, 3.326858e-002
4696, -8.809202e-002, 3.594310e-002, 3.326858e-002
4697, -8.791384e-002, 3.495682e-002, 3.326858e-002
4698, -8.773567e-002, 3.397053e-002, 3.326858e-002
4699, -8.755750e-002, 3.298425e-002, 3.326858e-002
4700, -8.737933e-002, 3.199796e-002, 3.326858e-002
4701, -8.720115e-002, 3.101168e-002, 3.326858e-002
4702, -8.702298e-002, 3.002540e-002, 3.326858e-002
4703, -8.684481e-002, 2.903911e-002, 3.326858e-002
4704, -8.666664e-002, 2.805283e-002, 3.326858e-002
4705, -8.648846e-002, 2.706654e-002, 3.326858e-002
4706, -8.631029e-002, 2.608026e-002, 3.326858e-002
4707, -8.613212e-002, 2.509398e-002, 3.326858e-002
4708, -8.595395e-002, 2.410769e-002, 3.326858e-002
4709, -8.577577e-002, 2.312141e-002, 3.326858e-002
4710, -8.559760e-002, 2.213512e-002, 3.326858e-002
4711, -8.541943e-002, 2.114884e-002, 3.326858e-002
4712, -8.524126e-002, 2.016256e-002, 3.326858e-002
4713, -8.506308e-002, 1.917627e-002, 3.326858e-002
4714, -8.488491e-002, 1.818999e-002, 3.326858e-002
4715, -8.470674e-002, 1.720370e-002, 3.326858e-002
4716, -8.452857e-002, 1.621741e-002, 3.326858e-002
4717, -8.435044e-002, 1.523111e-002, 3.326860e-002
4718, -8.417244e-002, 1.424477e-002, 3.326870e-002
4719, -8.399491e-002, 1.325828e-002, 3.326907e-002
4720, -8.381822e-002, 1.227159e-002, 3.326990e-002
4721, -8.364236e-002, 1.128477e-002, 3.327119e-002
4722, -8.346684e-002, 1.029803e-002, 3.327265e-002
4723, -8.264995e-002, 1.044522e-002, 3.272847e-002
4724, -8.133610e-002, 1.068151e-002, 3.127342e-002
4725, -8.193341e-002, 1.057416e-002, 3.205589e-002
4726, -8.087372e-002, 1.076454e-002, 3.040213e-002
4727, -8.055863e-002, 1.082100e-002, 2.946553e-002
4728, -8.039936e-002, 1.084944e-002, 2.848877e-002
4729, -8.040038e-002, 1.084908e-002, 2.749833e-002
4730, -8.056184e-002, 1.081989e-002, 2.652123e-002
4731, -8.087945e-002, 1.076260e-002, 2.558422e-002
4732, -8.134459e-002, 1.067872e-002, 2.471301e-002
4733, -8.194453e-002, 1.057047e-002, 2.393150e-002
4734, -8.266262e-002, 1.044070e-002, 2.326120e-002
4735, -8.347935e-002, 1.029301e-002, 2.272020e-002
4736, -8.437256e-002, 1.013151e-002, 2.232315e-002
4737, -8.531795e-002, 9.960619e-003, 2.208087e-002
4738, -8.628979e-002, 9.785012e-003, 2.200000e-002
4739, -8.726159e-002, 9.609480e-003, 2.208279e-002
4740, -8.820683e-002, 9.438812e-003, 2.232703e-002
4741, -8.909969e-002, 9.277659e-003, 2.272610e-002
4742, -8.991574e-002, 9.130397e-003, 2.326910e-002
4743, -9.063258e-002, 9.000978e-003, 2.394113e-002
4744, -9.123059e-002, 8.892836e-003, 2.472363e-002
4745, -9.169368e-002, 8.809024e-003, 2.559543e-002
4746, -9.200931e-002, 8.751875e-003, 2.653283e-002
4747, -9.216884e-002, 8.722977e-003, 2.751031e-002
4748, -9.216791e-002, 8.723168e-003, 2.850122e-002
4749, -9.200650e-002, 8.752490e-003, 2.947851e-002
4750, -9.168903e-002, 8.810142e-003, 3.041546e-002
4751, -9.122420e-002, 8.894531e-003, 3.128644e-002
4752, -9.062491e-002, 9.003330e-003, 3.206753e-002
4753, -8.990801e-002, 9.133499e-003, 3.273725e-002
4754, -8.909256e-002, 9.281343e-003, 3.327806e-002
4755, -1.181370e-001, 1.700460e-001, 3.327684e-002
4756, -1.179589e-001, 1.690598e-001, 3.327684e-002
4757, -1.177807e-001, 1.680736e-001, 3.327684e-002
4758, -1.176025e-001, 1.670873e-001, 3.327684e-002
4759, -1.174244e-001, 1.661010e-001, 3.327684e-002
4760, -1.172462e-001, 1.651146e-001, 3.327684e-002
4761, -1.170680e-001, 1.641283e-001, 3.327684e-002
4762, -1.168898e-001, 1.631420e-001, 3.327684e-002
4763, -1.167117e-001, 1.621557e-001, 3.327684e-002
4764, -1.165335e-001, 1.611694e-001, 3.327684e-002
4765, -1.163553e-001, 1.601832e-001, 3.327684e-002
4766, -1.161771e-001, 1.591969e-001, 3.327684e-002
4767, -1.159990e-001, 1.582106e-001, 3.327684e-002
4768, -1.158208e-001, 1.572243e-001, 3.327684e-002
4769, -1.156426e-001, 1.562380e-001, 3.327684e-002
4770, -1.154644e-001, 1.552517e-001, 3.327684e-002
4771, -1.152863e-001, 1.542655e-001, 3.327684e-002
4772, -1.151081e-001, 1.532792e-001, 3.327684e-002
4773, -1.149299e-001, 1.522929e-001, 3.327684e-002
4774, -1.147518e-001, 1.513066e-001, 3.327684e-002
4775, -1.145736e-001, 1.503203e-001, 3.327684e-002
4776, -1.143954e-001, 1.493340e-001, 3.327684e-002
4777, -1.142172e-001, 1.483477e-001, 3.327684e-002
4778, -1.140391e-001, 1.473615e-001, 3.327684e-002
4779, -1.138609e-001, 1.463752e-001, 3.327684e-002
4780, -1.136827e-001, 1.453889e-001, 3.327684e-002
4781, -1.135045e-001, 1.444026e-001, 3.327684e-002
4782, -1.133264e-001, 1.434163e-001, 3.327684e-002
4783, -1.131482e-001, 1.424300e-001, 3.327684e-002
4784, -1.129700e-001, 1.414438e-001, 3.327684e-002
4785, -1.127919e-001, 1.404575e-001, 3.327684e-002
4786, -1.126137e-001, 1.394712e-001, 3.327684e-002
4787, -1.124355e-001, 1.384849e-001, 3.327684e-002
4788, -1.122573e-001, 1.374986e-001, 3.327684e-002
4789, -1.120792e-001, 1.365123e-001, 3.327684e-002
4790, -1.119010e-001, 1.355261e-001, 3.327684e-002
4791, -1.117228e-001, 1.345398e-001, 3.327684e-002
4792, -1.115446e-001, 1.335535e-001, 3.327684e-002
4793, -1.113665e-001, 1.325672e-001, 3.327684e-002
4794, -1.111883e-001, 1.315809e-001, 3.327684e-002
4795, -1.110101e-001, 1.305946e-001, 3.327684e-002
4796, -1.108320e-001, 1.296083e-001, 3.327684e-002
4797, -1.106538e-001, 1.286221e-001, 3.327684e-002
4798, -1.104756e-001, 1.276358e-001, 3.327684e-002
4799, -1.102974e-001, 1.266495e-001, 3.327684e-002
4800, -1.101193e-001, 1.256632e-001, 3.327684e-002
4801, -1.099411e-001, 1.246769e-001, 3.327684e-002
4802, -1.097629e-001, 1.236906e-001, 3.327684e-002
4803, -1.095848e-001, 1.227044e-001, 3.327684e-002
4804, -1.094066e-001, 1.217181e-001, 3.327684e-002
4805, -1.092284e-001, 1.207318e-001, 3.327684e-002
4806, -1.090502e-001, 1.197455e-001, 3.327684e-002
4807, -1.088721e-001, 1.187592e-001, 3.327684e-002
4808, -1.086939e-001, 1.177729e-001, 3.327684e-002
4809, -1.085157e-001, 1.167867e-001, 3.327684e-002
4810, -1.083375e-001, 1.158004e-001, 3.327684e-002
4811, -1.081594e-001, 1.148141e-001, 3.327684e-002
4812, -1.079812e-001, 1.138278e-001, 3.327684e-002
4813, -1.078030e-001, 1.128415e-001, 3.327684e-002
4814, -1.076249e-001, 1.118552e-001, 3.327684e-002
4815, -1.074467e-001, 1.108689e-001, 3.327684e-002
4816, -1.072685e-001, 1.098827e-001, 3.327684e-002
4817, -1.070903e-001, 1.088964e-001, 3.327684e-002
4818, -1.069122e-001, 1.079101e-001, 3.327684e-002
4819, -1.067340e-001, 1.069238e-001, 3.327684e-002
4820, -1.065558e-001, 1.059375e-001, 3.327684e-002
4821, -1.063776e-001, 1.049512e-001, 3.327684e-002
4822, -1.061995e-001, 1.039650e-001, 3.327684e-002
4823, -1.060213e-001, 1.029787e-001, 3.327684e-002
4824, -1.058431e-001, 1.019924e-001, 3.327684e-002
4825, -1.056650e-001, 1.010061e-001, 3.327684e-002
4826, -1.054868e-001, 1.000198e-001, 3.327684e-002
4827, -1.053086e-001, 9.903354e-002, 3.327684e-002
4828, -1.051304e-001, 9.804726e-002, 3.327684e-002
4829, -1.049523e-001, 9.706097e-002, 3.327684e-002
4830, -1.047741e-001, 9.607469e-002, 3.327684e-002
4831, -1.045959e-001, 9.508840e-002, 3.327684e-002
4832, -1.044177e-001, 9.410212e-002, 3.327684e-002
4833, -1.042396e-001, 9.311583e-002, 3.327684e-002
4834, -1.040614e-001, 9.212955e-002, 3.327684e-002
4835, -1.038832e-001, 9.114327e-002, 3.327684e-002
4836, -1.037051e-001, 9.015698e-002, 3.327684e-002
4837, -1.035269e-001, 8.917070e-002, 3.327684e-002
4838, -1.033487e-001, 8.818441e-002, 3.327684e-002
4839, -1.031705e-001, 8.719813e-002, 3.327684e-002
4840, -1.029924e-001, 8.621185e-002, 3.327684e-002
4841, -1.028142e-001, 8.522556e-002, 3.327684e-002
4842, -1.026360e-001, 8.423928e-002, 3.327684e-002
4843, -1.024578e-001, 8.325299e-002, 3.327684e-002
4844, -1.022797e-001, 8.226671e-002, 3.327684e-002
4845, -1.021015e-001, 8.128042e-002, 3.327684e-002
4846, -1.019233e-001, 8.029414e-002, 3.327684e-002
4847, -1.017452e-001, 7.930786e-002, 3.327684e-002
4848, -1.015670e-001, 7.832157e-002, 3.327684e-002
4849, -1.013888e-001, 7.733529e-002, 3.327684e-002
4850, -1.012106e-001, 7.634900e-002, 3.327684e-002
4851, -1.010325e-001, 7.536272e-002, 3.327684e-002
4852, -1.008543e-001, 7.437644e-002, 3.327684e-002
4853, -1.006761e-001, 7.339015e-002, 3.327684e-002
4854, -1.004979e-001, 7.240387e-002, 3.327684e-002
4855, -1.003198e-001, 7.141758e-002, 3.327684e-002
4856, -1.001416e-001, 7.043130e-002, 3.327684e-002
4857, -9.996343e-002, 6.944501e-002, 3.327684e-002
4858, -9.978526e-002, 6.845873e-002, 3.327684e-002
4859, -9.960709e-002, 6.747245e-002, 3.327684e-002
4860, -9.942891e-002, 6.648616e-002, 3.327684e-002
4861, -9.925074e-002, 6.549988e-002, 3.327684e-002
4862, -9.907257e-002, 6.451359e-002, 3.327684e-002
4863, -9.889440e-002, 6.352731e-002, 3.327684e-002
4864, -9.871622e-002, 6.254103e-002, 3.327684e-002
4865, -9.853805e-002, 6.155474e-002, 3.327684e-002
4866, -9.835988e-002, 6.056846e-002, 3.327684e-002
4867, -9.818171e-002, 5.958217e-002, 3.327684e-002
4868, -9.800353e-002, 5.859589e-002, 3.327684e-002
4869, -9.782536e-002, 5.760961e-002, 3.327684e-002
4870, -9.764719e-002, 5.662332e-002, 3.327684e-002
4871, -9.746902e-002, 5.563704e-002, 3.327684e-002
4872, -9.729084e-002, 5.465075e-002, 3.327684e-002
4873, -9.711267e-002, 5.366447e-002, 3.327684e-002
4874, -9.693450e-002, 5.267818e-002, 3.327684e-002
4875, -9.675633e-002, 5.169190e-002, 3.327684e-002
4876, -9.657815e-002, 5.070562e-002, 3.327684e-002
4877, -9.639998e-002, 4.971933e-002, 3.327684e-002
4878, -9.622181e-002, 4.873305e-002, 3.327684e-002
4879, -9.604363e-002, 4.774676e-002, 3.327684e-002
4880, -9.586546e-002, 4.676048e-002, 3.327684e-002
4881, -9.568729e-002, 4.577420e-002, 3.327684e-002
4882, -9.550912e-002, 4.478791e-002, 3.327684e-002
4883, -9.533094e-002, 4.380163e-002, 3.327684e-002
4884, -9.515277e-002, 4.281534e-002, 3.327684e-002
4885, -9.497460e-002, 4.182906e-002, 3.327684e-002
4886, -9.479643e-002, 4.084277e-002, 3.327684e-002
4887, -9.461825e-002, 3.985649e-002, 3.327684e-002
4888, -9.444008e-002, 3.887021e-002, 3.327684e-002
4889, -9.426191e-002, 3.788392e-002, 3.327684e-002
4890, -9.408374e-002, 3.689764e-002, 3.327684e-002
4891, -9.390556e-002, 3.591135e-002, 3.327684e-002
4892, -9.372739e-002, 3.492507e-002, 3.327684e-002
4893, -9.354922e-002, 3.393879e-002, 3.327684e-002
4894, -9.337105e-002, 3.295250e-002, 3.327684e-002
4895, -9.319287e-002, 3.196622e-002, 3.327684e-002
4896, -9.301470e-002, 3.097993e-002, 3.327684e-002
4897, -9.283653e-002, 2.999365e-002, 3.327684e-002
4898, -9.265836e-002, 2.900736e-002, 3.327684e-002
4899, -9.248018e-002, 2.802108e-002, 3.327684e-002
4900, -9.230201e-002, 2.703480e-002, 3.327684e-002
4901, -9.212384e-002, 2.604851e-002, 3.327684e-002
4902, -9.194567e-002, 2.506223e-002, 3.327684e-002
4903, -9.176749e-002, 2.407594e-002, 3.327684e-002
4904, -9.158932e-002, 2.308966e-002, 3.327684e-002
4905, -9.141115e-002, 2.210338e-002, 3.327684e-002
4906, -9.123298e-002, 2.111709e-002, 3.327684e-002
4907, -9.105480e-002, 2.013081e-002, 3.327684e-002
4908, -9.087663e-002, 1.914452e-002, 3.327684e-002
4909, -9.069846e-002, 1.815824e-002, 3.327684e-002
4910, -9.052029e-002, 1.717195e-002, 3.327684e-002
4911, -9.034211e-002, 1.618567e-002, 3.327684e-002
4912, -9.016393e-002, 1.519938e-002, 3.327685e-002
4913, -8.998571e-002, 1.421306e-002, 3.327687e-002
4914, -8.980732e-002, 1.322666e-002, 3.327697e-002
4915, -8.962865e-002, 1.224018e-002, 3.327722e-002
4916, -8.944975e-002, 1.125372e-002, 3.327759e-002
4917, -8.927095e-002, 1.026744e-002, 3.327792e-002
4918, -1.116985e-001, 1.712094e-001, 3.273338e-002
4919, -1.109819e-001, 1.713393e-001, 3.206250e-002
4920, -1.103835e-001, 1.714485e-001, 3.128064e-002
4921, -1.099198e-001, 1.715333e-001, 3.040922e-002
4922, -1.096035e-001, 1.715911e-001, 2.947209e-002
4923, -1.094432e-001, 1.716204e-001, 2.849485e-002
4924, -1.094433e-001, 1.716205e-001, 2.750412e-002
4925, -1.096038e-001, 1.715913e-001, 2.652688e-002
4926, -1.099203e-001, 1.715336e-001, 2.558974e-002
4927, -1.103843e-001, 1.714491e-001, 2.471828e-002
4928, -1.109832e-001, 1.713403e-001, 2.393630e-002
4929, -1.117007e-001, 1.712109e-001, 2.326515e-002
4930, -1.125171e-001, 1.710641e-001, 2.272316e-002
4931, -1.134103e-001, 1.709034e-001, 2.232509e-002
4932, -1.143557e-001, 1.707330e-001, 2.208183e-002
4933, -1.153276e-001, 1.705576e-001, 2.200000e-002
4934, -1.162994e-001, 1.703819e-001, 2.208183e-002
4935, -1.172446e-001, 1.702108e-001, 2.232510e-002
4936, -1.181376e-001, 1.700489e-001, 2.272316e-002
4937, -1.189538e-001, 1.699007e-001, 2.326516e-002
4938, -1.196712e-001, 1.697708e-001, 2.393631e-002
4939, -1.202703e-001, 1.696631e-001, 2.471831e-002
4940, -1.207345e-001, 1.695800e-001, 2.558983e-002
4941, -1.210512e-001, 1.695233e-001, 2.652709e-002
4942, -1.212118e-001, 1.694945e-001, 2.750453e-002
4943, -1.212118e-001, 1.694944e-001, 2.849548e-002
4944, -1.210512e-001, 1.695229e-001, 2.947292e-002
4945, -1.207344e-001, 1.695792e-001, 3.041018e-002
4946, -1.202701e-001, 1.696620e-001, 3.128169e-002
4947, -1.196710e-001, 1.697694e-001, 3.206369e-002
4948, -1.189534e-001, 1.698987e-001, 3.273484e-002
4949, -1.115191e-001, 1.702244e-001, 3.273233e-002
4950, -1.107933e-001, 1.662818e-001, 3.272185e-002
4951, -1.109752e-001, 1.672692e-001, 3.272454e-002
4952, -9.008641e-002, 1.011940e-002, 3.273702e-002
4953, -1.113390e-001, 1.692403e-001, 3.273052e-002
4954, -1.104345e-001, 1.643083e-001, 3.272006e-002
4955, -1.106133e-001, 1.652948e-001, 3.272057e-002
4956, -1.102561e-001, 1.633220e-001, 3.271992e-002
4957, -1.100779e-001, 1.623357e-001, 3.271987e-002
4958, -1.098997e-001, 1.613494e-001, 3.271986e-002
4959, -1.097215e-001, 1.603631e-001, 3.271986e-002
4960, -1.095433e-001, 1.593768e-001, 3.271986e-002
4961, -1.093651e-001, 1.583905e-001, 3.271986e-002
4962, -1.091870e-001, 1.574042e-001, 3.271986e-002
4963, -1.090088e-001, 1.564179e-001, 3.271986e-002
4964, -1.088306e-001, 1.554317e-001, 3.271986e-002
4965, -1.086525e-001, 1.544454e-001, 3.271986e-002
4966, -1.084743e-001, 1.534591e-001, 3.271986e-002
4967, -1.082961e-001, 1.524728e-001, 3.271986e-002
4968, -1.081179e-001, 1.514865e-001, 3.271986e-002
4969, -1.079398e-001, 1.505002e-001, 3.271986e-002
4970, -1.077616e-001, 1.495140e-001, 3.271986e-002
4971, -1.075834e-001, 1.485277e-001, 3.271986e-002
4972, -1.074052e-001, 1.475414e-001, 3.271986e-002
4973, -1.072271e-001, 1.465551e-001, 3.271986e-002
4974, -1.070489e-001, 1.455688e-001, 3.271986e-002
4975, -1.068707e-001, 1.445825e-001, 3.271986e-002
4976, -1.066926e-001, 1.435963e-001, 3.271986e-002
4977, -1.065144e-001, 1.426100e-001, 3.271986e-002
4978, -1.063362e-001, 1.416237e-001, 3.271986e-002
4979, -1.061580e-001, 1.406374e-001, 3.271986e-002
4980, -1.059799e-001, 1.396511e-001, 3.271986e-002
4981, -1.058017e-001, 1.386648e-001, 3.271986e-002
4982, -1.056235e-001, 1.376786e-001, 3.271986e-002
4983, -1.054453e-001, 1.366923e-001, 3.271986e-002
4984, -1.052672e-001, 1.357060e-001, 3.271986e-002
4985, -1.050890e-001, 1.347197e-001, 3.271986e-002
4986, -1.049108e-001, 1.337334e-001, 3.271986e-002
4987, -1.047327e-001, 1.327471e-001, 3.271986e-002
4988, -1.045545e-001, 1.317608e-001, 3.271986e-002
4989, -1.043763e-001, 1.307746e-001, 3.271986e-002
4990, -1.041981e-001, 1.297883e-001, 3.271986e-002
4991, -1.040200e-001, 1.288020e-001, 3.271986e-002
4992, -1.038418e-001, 1.278157e-001, 3.271986e-002
4993, -1.036636e-001, 1.268294e-001, 3.271986e-002
4994, -1.034855e-001, 1.258431e-001, 3.271986e-002
4995, -1.033073e-001, 1.248569e-001, 3.271986e-002
4996, -1.031291e-001, 1.238706e-001, 3.271986e-002
4997, -1.029509e-001, 1.228843e-001, 3.271986e-002
4998, -1.027728e-001, 1.218980e-001, 3.271986e-002
4999, -1.025946e-001, 1.209117e-001, 3.271986e-002
5000, -1.024164e-001, 1.199254e-001, 3.271986e-002
5001, -1.022382e-001, 1.189392e-001, 3.271986e-002
5002, -1.020601e-001, 1.179529e-001, 3.271986e-002
5003, -1.018819e-001, 1.169666e-001, 3.271986e-002
5004, -1.017037e-001, 1.159803e-001, 3.271986e-002
5005, -1.015256e-001, 1.149940e-001, 3.271986e-002
5006, -1.013474e-001, 1.140077e-001, 3.271986e-002
5007, -1.011692e-001, 1.130214e-001, 3.271986e-002
5008, -1.009910e-001, 1.120352e-001, 3.271986e-002
5009, -1.008129e-001, 1.110489e-001, 3.271986e-002
5010, -1.006347e-001, 1.100626e-001, 3.271986e-002
5011, -1.004565e-001, 1.090763e-001, 3.271986e-002
5012, -1.002783e-001, 1.080900e-001, 3.271986e-002
5013, -1.001002e-001, 1.071037e-001, 3.271986e-002
5014, -9.992200e-002, 1.061175e-001, 3.271986e-002
5015, -9.974383e-002, 1.051312e-001, 3.271986e-002
5016, -9.956566e-002, 1.041449e-001, 3.271986e-002
5017, -9.938748e-002, 1.031586e-001, 3.271986e-002
5018, -9.920931e-002, 1.021723e-001, 3.271986e-002
5019, -9.903114e-002, 1.011860e-001, 3.271986e-002
5020, -9.885296e-002, 1.001998e-001, 3.271986e-002
5021, -9.867479e-002, 9.921347e-002, 3.271986e-002
5022, -9.849662e-002, 9.822718e-002, 3.271986e-002
5023, -9.831845e-002, 9.724090e-002, 3.271986e-002
5024, -9.814027e-002, 9.625462e-002, 3.271986e-002
5025, -9.796210e-002, 9.526833e-002, 3.271986e-002
5026, -9.778393e-002, 9.428205e-002, 3.271986e-002
5027, -9.760576e-002, 9.329576e-002, 3.271986e-002
5028, -9.742758e-002, 9.230948e-002, 3.271986e-002
5029, -9.724941e-002, 9.132320e-002, 3.271986e-002
5030, -9.707124e-002, 9.033691e-002, 3.271986e-002
5031, -9.689307e-002, 8.935063e-002, 3.271986e-002
5032, -9.671489e-002, 8.836434e-002, 3.271986e-002
5033, -9.653672e-002, 8.737806e-002, 3.271986e-002
5034, -9.635855e-002, 8.639178e-002, 3.271986e-002
5035, -9.618038e-002, 8.540549e-002, 3.271986e-002
5036, -9.600220e-002, 8.441921e-002, 3.271986e-002
5037, -9.582403e-002, 8.343292e-002, 3.271986e-002
5038, -9.564586e-002, 8.244664e-002, 3.271986e-002
5039, -9.546769e-002, 8.146035e-002, 3.271986e-002
5040, -9.528951e-002, 8.047407e-002, 3.271986e-002
5041, -9.511134e-002, 7.948779e-002, 3.271986e-002
5042, -9.493317e-002, 7.850150e-002, 3.271986e-002
5043, -9.475500e-002, 7.751522e-002, 3.271986e-002
5044, -9.457682e-002, 7.652893e-002, 3.271986e-002
5045, -9.439865e-002, 7.554265e-002, 3.271986e-002
5046, -9.422048e-002, 7.455637e-002, 3.271986e-002
5047, -9.404231e-002, 7.357008e-002, 3.271986e-002
5048, -9.386413e-002, 7.258380e-002, 3.271986e-002
5049, -9.368596e-002, 7.159751e-002, 3.271986e-002
5050, -9.350779e-002, 7.061123e-002, 3.271986e-002
5051, -9.332962e-002, 6.962494e-002, 3.271986e-002
5052, -9.315144e-002, 6.863866e-002, 3.271986e-002
5053, -9.297327e-002, 6.765238e-002, 3.271986e-002
5054, -9.279510e-002, 6.666609e-002, 3.271986e-002
5055, -9.261692e-002, 6.567981e-002, 3.271986e-002
5056, -9.243875e-002, 6.469352e-002, 3.271986e-002
5057, -9.226058e-002, 6.370724e-002, 3.271986e-002
5058, -9.208241e-002, 6.272096e-002, 3.271986e-002
5059, -9.190423e-002, 6.173467e-002, 3.271986e-002
5060, -9.172606e-002, 6.074839e-002, 3.271986e-002
5061, -9.154789e-002, 5.976210e-002, 3.271986e-002
5062, -9.136972e-002, 5.877582e-002, 3.271986e-002
5063, -9.119154e-002, 5.778953e-002, 3.271986e-002
5064, -9.101337e-002, 5.680325e-002, 3.271986e-002
5065, -9.083520e-002, 5.581697e-002, 3.271986e-002
5066, -9.065703e-002, 5.483068e-002, 3.271986e-002
5067, -9.047885e-002, 5.384440e-002, 3.271986e-002
5068, -9.030068e-002, 5.285811e-002, 3.271986e-002
5069, -9.012251e-002, 5.187183e-002, 3.271986e-002
5070, -8.994434e-002, 5.088555e-002, 3.271986e-002
5071, -8.976616e-002, 4.989926e-002, 3.271986e-002
5072, -8.958799e-002, 4.891298e-002, 3.271986e-002
5073, -8.940982e-002, 4.792669e-002, 3.271986e-002
5074, -8.923165e-002, 4.694041e-002, 3.271986e-002
5075, -8.905347e-002, 4.595413e-002, 3.271986e-002
5076, -8.887530e-002, 4.496784e-002, 3.271986e-002
5077, -8.869713e-002, 4.398156e-002, 3.271986e-002
5078, -8.851896e-002, 4.299527e-002, 3.271986e-002
5079, -8.834078e-002, 4.200899e-002, 3.271986e-002
5080, -8.816261e-002, 4.102270e-002, 3.271986e-002
5081, -8.798444e-002, 4.003642e-002, 3.271986e-002
5082, -8.780627e-002, 3.905014e-002, 3.271986e-002
5083, -8.762809e-002, 3.806385e-002, 3.271986e-002
5084, -8.744992e-002, 3.707757e-002, 3.271986e-002
5085, -8.727175e-002, 3.609128e-002, 3.271986e-002
5086, -8.709358e-002, 3.510500e-002, 3.271986e-002
5087, -8.691540e-002, 3.411872e-002, 3.271986e-002
5088, -8.673723e-002, 3.313243e-002, 3.271986e-002
5089, -8.655906e-002, 3.214615e-002, 3.271986e-002
5090, -8.638088e-002, 3.115986e-002, 3.271986e-002
5091, -8.620271e-002, 3.017358e-002, 3.271986e-002
5092, -8.602454e-002, 2.918729e-002, 3.271986e-002
5093, -8.584637e-002, 2.820101e-002, 3.271986e-002
5094, -8.566819e-002, 2.721473e-002, 3.271986e-002
5095, -8.549002e-002, 2.622844e-002, 3.271986e-002
5096, -8.531185e-002, 2.524216e-002, 3.271986e-002
5097, -8.513368e-002, 2.425587e-002, 3.271986e-002
5098, -8.495550e-002, 2.326959e-002, 3.271986e-002
5099, -8.477733e-002, 2.228331e-002, 3.271986e-002
5100, -8.459916e-002, 2.129702e-002, 3.271986e-002
5101, -8.442099e-002, 2.031074e-002, 3.271986e-002
5102, -8.424281e-002, 1.932445e-002, 3.271986e-002
5103, -8.406464e-002, 1.833817e-002, 3.271986e-002
5104, -8.388649e-002, 1.735187e-002, 3.271987e-002
5105, -8.370840e-002, 1.636554e-002, 3.271995e-002
5106, -8.353045e-002, 1.537916e-002, 3.272013e-002
5107, -8.335281e-002, 1.439267e-002, 3.272057e-002
5108, -8.317588e-002, 1.340597e-002, 3.272159e-002
5109, -8.300002e-002, 1.241902e-002, 3.272346e-002
5110, -8.282500e-002, 1.143199e-002, 3.272600e-002
5111, -8.073592e-002, 1.180632e-002, 2.946276e-002
5112, -8.105022e-002, 1.175036e-002, 3.039855e-002
5113, -8.057713e-002, 1.183441e-002, 2.848673e-002
5114, -8.151166e-002, 1.166785e-002, 3.126947e-002
5115, -8.210831e-002, 1.156085e-002, 3.205230e-002
5116, -8.057839e-002, 1.183379e-002, 2.749691e-002
5117, -8.073998e-002, 1.180446e-002, 2.652015e-002
5118, -8.105769e-002, 1.174707e-002, 2.558335e-002
5119, -8.152291e-002, 1.166312e-002, 2.471229e-002
5120, -8.212290e-002, 1.155482e-002, 2.393091e-002
5121, -8.284111e-002, 1.142504e-002, 2.326069e-002
5122, -8.365796e-002, 1.127738e-002, 2.271978e-002
5123, -8.455127e-002, 1.111590e-002, 2.232285e-002
5124, -8.549673e-002, 1.094502e-002, 2.208072e-002
5125, -8.646859e-002, 1.076942e-002, 2.200000e-002
5126, -8.744037e-002, 1.059388e-002, 2.208295e-002
5127, -8.838555e-002, 1.042320e-002, 2.232733e-002
5128, -8.927830e-002, 1.026203e-002, 2.272652e-002
5129, -9.009422e-002, 1.011474e-002, 2.326961e-002
5130, -9.081095e-002, 9.985318e-003, 2.394171e-002
5131, -9.140889e-002, 9.877232e-003, 2.472435e-002
5132, -9.187189e-002, 9.793483e-003, 2.559626e-002
5133, -9.218739e-002, 9.736390e-003, 2.653373e-002
5134, -9.234679e-002, 9.707585e-003, 2.751122e-002
5135, -9.234574e-002, 9.707954e-003, 2.850204e-002
5136, -9.218429e-002, 9.737505e-003, 2.947912e-002
5137, -9.186687e-002, 9.795394e-003, 3.041578e-002
5138, -9.140223e-002, 9.880010e-003, 3.128644e-002
5139, -9.080324e-002, 9.989025e-003, 3.206725e-002
5140, -1.111576e-001, 1.682557e-001, 3.272780e-002
5141, -1.187753e-001, 1.689125e-001, 3.273484e-002
5142, -1.185972e-001, 1.679265e-001, 3.273484e-002
5143, -1.184190e-001, 1.669403e-001, 3.273484e-002
5144, -1.182408e-001, 1.659539e-001, 3.273484e-002
5145, -1.180626e-001, 1.649673e-001, 3.273484e-002
5146, -1.178844e-001, 1.639809e-001, 3.273484e-002
5147, -1.177062e-001, 1.629946e-001, 3.273484e-002
5148, -1.175280e-001, 1.620083e-001, 3.273484e-002
5149, -1.173499e-001, 1.610220e-001, 3.273484e-002
5150, -1.171717e-001, 1.600357e-001, 3.273484e-002
5151, -1.169935e-001, 1.590494e-001, 3.273484e-002
5152, -1.168153e-001, 1.580631e-001, 3.273484e-002
5153, -1.166372e-001, 1.570768e-001, 3.273484e-002
5154, -1.164590e-001, 1.560905e-001, 3.273484e-002
5155, -1.162808e-001, 1.551043e-001, 3.273484e-002
5156, -1.161027e-001, 1.541180e-001, 3.273484e-002
5157, -1.159245e-001, 1.531317e-001, 3.273484e-002
5158, -1.157463e-001, 1.521454e-001, 3.273484e-002
5159, -1.155681e-001, 1.511591e-001, 3.273484e-002
5160, -1.153900e-001, 1.501728e-001, 3.273484e-002
5161, -1.152118e-001, 1.491866e-001, 3.273484e-002
5162, -1.150336e-001, 1.482003e-001, 3.273484e-002
5163, -1.148554e-001, 1.472140e-001, 3.273484e-002
5164, -1.146773e-001, 1.462277e-001, 3.273484e-002
5165, -1.144991e-001, 1.452414e-001, 3.273484e-002
5166, -1.143209e-001, 1.442551e-001, 3.273484e-002
5167, -1.141428e-001, 1.432688e-001, 3.273484e-002
5168, -1.139646e-001, 1.422826e-001, 3.273484e-002
5169, -1.137864e-001, 1.412963e-001, 3.273484e-002
5170, -1.136082e-001, 1.403100e-001, 3.273484e-002
5171, -1.134301e-001, 1.393237e-001, 3.273484e-002
5172, -1.132519e-001, 1.383374e-001, 3.273484e-002
5173, -1.130737e-001, 1.373511e-001, 3.273484e-002
5174, -1.128955e-001, 1.363649e-001, 3.273484e-002
5175, -1.127174e-001, 1.353786e-001, 3.273484e-002
5176, -1.125392e-001, 1.343923e-001, 3.273484e-002
5177, -1.123610e-001, 1.334060e-001, 3.273484e-002
5178, -1.121829e-001, 1.324197e-001, 3.273484e-002
5179, -1.120047e-001, 1.314334e-001, 3.273484e-002
5180, -1.118265e-001, 1.304472e-001, 3.273484e-002
5181, -1.116483e-001, 1.294609e-001, 3.273484e-002
5182, -1.114702e-001, 1.284746e-001, 3.273484e-002
5183, -1.112920e-001, 1.274883e-001, 3.273484e-002
5184, -1.111138e-001, 1.265020e-001, 3.273484e-002
5185, -1.109356e-001, 1.255157e-001, 3.273484e-002
5186, -1.107575e-001, 1.245294e-001, 3.273484e-002
5187, -1.105793e-001, 1.235432e-001, 3.273484e-002
5188, -1.104011e-001, 1.225569e-001, 3.273484e-002
5189, -1.102230e-001, 1.215706e-001, 3.273484e-002
5190, -1.100448e-001, 1.205843e-001, 3.273484e-002
5191, -1.098666e-001, 1.195980e-001, 3.273484e-002
5192, -1.096884e-001, 1.186117e-001, 3.273484e-002
5193, -1.095103e-001, 1.176255e-001, 3.273484e-002
5194, -1.093321e-001, 1.166392e-001, 3.273484e-002
5195, -1.091539e-001, 1.156529e-001, 3.273484e-002
5196, -1.089757e-001, 1.146666e-001, 3.273484e-002
5197, -1.087976e-001, 1.136803e-001, 3.273484e-002
5198, -1.086194e-001, 1.126940e-001, 3.273484e-002
5199, -1.084412e-001, 1.117078e-001, 3.273484e-002
5200, -1.082631e-001, 1.107215e-001, 3.273484e-002
5201, -1.080849e-001, 1.097352e-001, 3.273484e-002
5202, -1.079067e-001, 1.087489e-001, 3.273484e-002
5203, -1.077285e-001, 1.077626e-001, 3.273484e-002
5204, -1.075504e-001, 1.067763e-001, 3.273484e-002
5205, -1.073722e-001, 1.057900e-001, 3.273484e-002
5206, -1.071940e-001, 1.048038e-001, 3.273484e-002
5207, -1.070158e-001, 1.038175e-001, 3.273484e-002
5208, -1.068377e-001, 1.028312e-001, 3.273484e-002
5209, -1.066595e-001, 1.018449e-001, 3.273484e-002
5210, -1.064813e-001, 1.008586e-001, 3.273484e-002
5211, -1.063032e-001, 9.987234e-002, 3.273484e-002
5212, -1.061250e-001, 9.888606e-002, 3.273484e-002
5213, -1.059468e-001, 9.789978e-002, 3.273484e-002
5214, -1.057686e-001, 9.691349e-002, 3.273484e-002
5215, -1.055905e-001, 9.592721e-002, 3.273484e-002
5216, -1.054123e-001, 9.494092e-002, 3.273484e-002
5217, -1.052341e-001, 9.395464e-002, 3.273484e-002
5218, -1.050560e-001, 9.296836e-002, 3.273484e-002
5219, -1.048778e-001, 9.198207e-002, 3.273484e-002
5220, -1.046996e-001, 9.099579e-002, 3.273484e-002
5221, -1.045214e-001, 9.000950e-002, 3.273484e-002
5222, -1.043433e-001, 8.902322e-002, 3.273484e-002
5223, -1.041651e-001, 8.803693e-002, 3.273484e-002
5224, -1.039869e-001, 8.705065e-002, 3.273484e-002
5225, -1.038087e-001, 8.606437e-002, 3.273484e-002
5226, -1.036306e-001, 8.507808e-002, 3.273484e-002
5227, -1.034524e-001, 8.409180e-002, 3.273484e-002
5228, -1.032742e-001, 8.310551e-002, 3.273484e-002
5229, -1.030961e-001, 8.211923e-002, 3.273484e-002
5230, -1.029179e-001, 8.113295e-002, 3.273484e-002
5231, -1.027397e-001, 8.014666e-002, 3.273484e-002
5232, -1.025615e-001, 7.916038e-002, 3.273484e-002
5233, -1.023834e-001, 7.817409e-002, 3.273484e-002
5234, -1.022052e-001, 7.718781e-002, 3.273484e-002
5235, -1.020270e-001, 7.620152e-002, 3.273484e-002
5236, -1.018488e-001, 7.521524e-002, 3.273484e-002
5237, -1.016707e-001, 7.422896e-002, 3.273484e-002
5238, -1.014925e-001, 7.324267e-002, 3.273484e-002
5239, -1.013143e-001, 7.225639e-002, 3.273484e-002
5240, -1.011362e-001, 7.127010e-002, 3.273484e-002
5241, -1.009580e-001, 7.028382e-002, 3.273484e-002
5242, -1.007798e-001, 6.929754e-002, 3.273484e-002
5243, -1.006016e-001, 6.831125e-002, 3.273484e-002
5244, -1.004235e-001, 6.732497e-002, 3.273484e-002
5245, -1.002453e-001, 6.633868e-002, 3.273484e-002
5246, -1.000671e-001, 6.535240e-002, 3.273484e-002
5247, -9.988895e-002, 6.436612e-002, 3.273484e-002
5248, -9.971077e-002, 6.337983e-002, 3.273484e-002
5249, -9.953260e-002, 6.239355e-002, 3.273484e-002
5250, -9.935443e-002, 6.140726e-002, 3.273484e-002
5251, -9.917626e-002, 6.042098e-002, 3.273484e-002
5252, -9.899808e-002, 5.943469e-002, 3.273484e-002
5253, -9.881991e-002, 5.844841e-002, 3.273484e-002
5254, -9.864174e-002, 5.746213e-002, 3.273484e-002
5255, -9.846357e-002, 5.647584e-002, 3.273484e-002
5256, -9.828539e-002, 5.548956e-002, 3.273484e-002
5257, -9.810722e-002, 5.450327e-002, 3.273484e-002
5258, -9.792905e-002, 5.351699e-002, 3.273484e-002
5259, -9.775088e-002, 5.253071e-002, 3.273484e-002
5260, -9.757270e-002, 5.154442e-002, 3.273484e-002
5261, -9.739453e-002, 5.055814e-002, 3.273484e-002
5262, -9.721636e-002, 4.957185e-002, 3.273484e-002
5263, -9.703819e-002, 4.858557e-002, 3.273484e-002
5264, -9.686001e-002, 4.759928e-002, 3.273484e-002
5265, -9.668184e-002, 4.661300e-002, 3.273484e-002
5266, -9.650367e-002, 4.562672e-002, 3.273484e-002
5267, -9.632549e-002, 4.464043e-002, 3.273484e-002
5268, -9.614732e-002, 4.365415e-002, 3.273484e-002
5269, -9.596915e-002, 4.266786e-002, 3.273484e-002
5270, -9.579098e-002, 4.168158e-002, 3.273484e-002
5271, -9.561280e-002, 4.069530e-002, 3.273484e-002
5272, -9.543463e-002, 3.970901e-002, 3.273484e-002
5273, -9.525646e-002, 3.872273e-002, 3.273484e-002
5274, -9.507829e-002, 3.773644e-002, 3.273484e-002
5275, -9.490011e-002, 3.675016e-002, 3.273484e-002
5276, -9.472194e-002, 3.576387e-002, 3.273484e-002
5277, -9.454377e-002, 3.477759e-002, 3.273484e-002
5278, -9.436560e-002, 3.379131e-002, 3.273484e-002
5279, -9.418742e-002, 3.280502e-002, 3.273484e-002
5280, -9.400925e-002, 3.181874e-002, 3.273484e-002
5281, -9.383108e-002, 3.083245e-002, 3.273484e-002
5282, -9.365291e-002, 2.984617e-002, 3.273484e-002
5283, -9.347473e-002, 2.885989e-002, 3.273484e-002
5284, -9.329656e-002, 2.787360e-002, 3.273484e-002
5285, -9.311839e-002, 2.688732e-002, 3.273484e-002
5286, -9.294022e-002, 2.590103e-002, 3.273484e-002
5287, -9.276204e-002, 2.491475e-002, 3.273484e-002
5288, -9.258387e-002, 2.392846e-002, 3.273484e-002
5289, -9.240570e-002, 2.294218e-002, 3.273484e-002
5290, -9.222753e-002, 2.195590e-002, 3.273484e-002
5291, -9.204935e-002, 2.096961e-002, 3.273484e-002
5292, -9.187118e-002, 1.998333e-002, 3.273484e-002
5293, -9.169301e-002, 1.899704e-002, 3.273484e-002
5294, -9.151484e-002, 1.801076e-002, 3.273484e-002
5295, -9.133666e-002, 1.702448e-002, 3.273484e-002
5296, -9.115848e-002, 1.603818e-002, 3.273485e-002
5297, -9.098027e-002, 1.505185e-002, 3.273487e-002
5298, -9.080194e-002, 1.406543e-002, 3.273498e-002
5299, -9.062337e-002, 1.307887e-002, 3.273524e-002
5300, -9.044445e-002, 1.209222e-002, 3.273576e-002
5301, -9.026533e-002, 1.110565e-002, 3.273644e-002
5302, -1.108028e-001, 1.703552e-001, 3.206111e-002
5303, -1.102048e-001, 1.704652e-001, 3.127899e-002
5304, -1.097414e-001, 1.705501e-001, 3.040748e-002
5305, -1.094254e-001, 1.706078e-001, 2.947050e-002
5306, -1.092654e-001, 1.706369e-001, 2.849360e-002
5307, -1.092657e-001, 1.706368e-001, 2.750329e-002
5308, -1.094262e-001, 1.706078e-001, 2.652643e-002
5309, -1.097428e-001, 1.705505e-001, 2.558955e-002
5310, -1.102068e-001, 1.704663e-001, 2.471822e-002
5311, -1.108057e-001, 1.703578e-001, 2.393629e-002
5312, -1.115232e-001, 1.702286e-001, 2.326515e-002
5313, -1.123396e-001, 1.700815e-001, 2.272315e-002
5314, -1.132327e-001, 1.699204e-001, 2.232509e-002
5315, -1.141780e-001, 1.697496e-001, 2.208183e-002
5316, -1.151499e-001, 1.695740e-001, 2.200000e-002
5317, -1.161217e-001, 1.693984e-001, 2.208183e-002
5318, -1.170670e-001, 1.692275e-001, 2.232510e-002
5319, -1.179600e-001, 1.690659e-001, 2.272316e-002
5320, -1.187763e-001, 1.689181e-001, 2.326516e-002
5321, -1.194937e-001, 1.687884e-001, 2.393632e-002
5322, -1.200928e-001, 1.686807e-001, 2.471832e-002
5323, -1.205570e-001, 1.685972e-001, 2.558984e-002
5324, -1.208736e-001, 1.685401e-001, 2.652710e-002
5325, -1.210341e-001, 1.685110e-001, 2.750454e-002
5326, -1.210340e-001, 1.685105e-001, 2.849549e-002
5327, -1.208734e-001, 1.685386e-001, 2.947292e-002
5328, -1.205565e-001, 1.685945e-001, 3.041018e-002
5329, -1.200921e-001, 1.686769e-001, 3.128169e-002
5330, -1.194929e-001, 1.687837e-001, 3.206369e-002
5331, -1.098941e-001, 1.654252e-001, 3.204169e-002
5332, -1.100749e-001, 1.664129e-001, 3.204426e-002
5333, -1.102578e-001, 1.674013e-001, 3.204889e-002
5334, -1.104410e-001, 1.683881e-001, 3.205420e-002
5335, -1.097149e-001, 1.644384e-001, 3.204071e-002
5336, -1.095364e-001, 1.634520e-001, 3.204039e-002
5337, -1.090017e-001, 1.604931e-001, 3.204020e-002
5338, -1.091799e-001, 1.614794e-001, 3.204020e-002
5339, -1.088236e-001, 1.595068e-001, 3.204019e-002
5340, -1.086454e-001, 1.585205e-001, 3.204019e-002
5341, -1.084672e-001, 1.575343e-001, 3.204019e-002
5342, -1.082890e-001, 1.565480e-001, 3.204019e-002
5343, -1.081109e-001, 1.555617e-001, 3.204019e-002
5344, -1.079327e-001, 1.545754e-001, 3.204019e-002
5345, -1.077545e-001, 1.535891e-001, 3.204019e-002
5346, -1.075764e-001, 1.526028e-001, 3.204019e-002
5347, -1.073982e-001, 1.516166e-001, 3.204019e-002
5348, -1.072200e-001, 1.506303e-001, 3.204019e-002
5349, -1.070418e-001, 1.496440e-001, 3.204019e-002
5350, -1.068637e-001, 1.486577e-001, 3.204019e-002
5351, -1.066855e-001, 1.476714e-001, 3.204019e-002
5352, -1.065073e-001, 1.466851e-001, 3.204019e-002
5353, -1.063291e-001, 1.456988e-001, 3.204019e-002
5354, -1.061510e-001, 1.447126e-001, 3.204019e-002
5355, -1.059728e-001, 1.437263e-001, 3.204019e-002
5356, -1.057946e-001, 1.427400e-001, 3.204019e-002
5357, -1.056165e-001, 1.417537e-001, 3.204019e-002
5358, -1.054383e-001, 1.407674e-001, 3.204019e-002
5359, -1.052601e-001, 1.397811e-001, 3.204019e-002
5360, -1.050819e-001, 1.387949e-001, 3.204019e-002
5361, -1.049038e-001, 1.378086e-001, 3.204019e-002
5362, -1.047256e-001, 1.368223e-001, 3.204019e-002
5363, -1.045474e-001, 1.358360e-001, 3.204019e-002
5364, -1.043692e-001, 1.348497e-001, 3.204019e-002
5365, -1.041911e-001, 1.338634e-001, 3.204019e-002
5366, -1.040129e-001, 1.328772e-001, 3.204019e-002
5367, -1.038347e-001, 1.318909e-001, 3.204019e-002
5368, -1.036566e-001, 1.309046e-001, 3.204019e-002
5369, -1.034784e-001, 1.299183e-001, 3.204019e-002
5370, -1.033002e-001, 1.289320e-001, 3.204019e-002
5371, -1.031220e-001, 1.279457e-001, 3.204019e-002
5372, -1.029439e-001, 1.269595e-001, 3.204019e-002
5373, -1.027657e-001, 1.259732e-001, 3.204019e-002
5374, -1.025875e-001, 1.249869e-001, 3.204019e-002
5375, -1.024093e-001, 1.240006e-001, 3.204019e-002
5376, -1.022312e-001, 1.230143e-001, 3.204019e-002
5377, -1.020530e-001, 1.220280e-001, 3.204019e-002
5378, -1.018748e-001, 1.210417e-001, 3.204019e-002
5379, -1.016967e-001, 1.200555e-001, 3.204019e-002
5380, -1.015185e-001, 1.190692e-001, 3.204019e-002
5381, -1.013403e-001, 1.180829e-001, 3.204019e-002
5382, -1.011621e-001, 1.170966e-001, 3.204019e-002
5383, -1.009840e-001, 1.161103e-001, 3.204019e-002
5384, -1.008058e-001, 1.151240e-001, 3.204019e-002
5385, -1.006276e-001, 1.141378e-001, 3.204019e-002
5386, -1.004494e-001, 1.131515e-001, 3.204019e-002
5387, -1.002713e-001, 1.121652e-001, 3.204019e-002
5388, -1.000931e-001, 1.111789e-001, 3.204019e-002
5389, -9.991493e-002, 1.101926e-001, 3.204019e-002
5390, -9.973676e-002, 1.092063e-001, 3.204019e-002
5391, -9.955859e-002, 1.082201e-001, 3.204019e-002
5392, -9.938041e-002, 1.072338e-001, 3.204019e-002
5393, -9.920224e-002, 1.062475e-001, 3.204019e-002
5394, -9.902407e-002, 1.052612e-001, 3.204019e-002
5395, -9.884590e-002, 1.042749e-001, 3.204019e-002
5396, -9.866772e-002, 1.032886e-001, 3.204019e-002
5397, -9.848955e-002, 1.023023e-001, 3.204019e-002
5398, -9.831138e-002, 1.013161e-001, 3.204019e-002
5399, -9.813321e-002, 1.003298e-001, 3.204019e-002
5400, -9.795503e-002, 9.934349e-002, 3.204019e-002
5401, -9.777686e-002, 9.835721e-002, 3.204019e-002
5402, -9.759869e-002, 9.737093e-002, 3.204019e-002
5403, -9.742052e-002, 9.638464e-002, 3.204019e-002
5404, -9.724234e-002, 9.539836e-002, 3.204019e-002
5405, -9.706417e-002, 9.441207e-002, 3.204019e-002
5406, -9.688600e-002, 9.342579e-002, 3.204019e-002
5407, -9.670783e-002, 9.243950e-002, 3.204019e-002
5408, -9.652965e-002, 9.145322e-002, 3.204019e-002
5409, -9.635148e-002, 9.046694e-002, 3.204019e-002
5410, -9.617331e-002, 8.948065e-002, 3.204019e-002
5411, -9.599514e-002, 8.849437e-002, 3.204019e-002
5412, -9.581696e-002, 8.750808e-002, 3.204019e-002
5413, -9.563879e-002, 8.652180e-002, 3.204019e-002
5414, -9.546062e-002, 8.553552e-002, 3.204019e-002
5415, -9.528245e-002, 8.454923e-002, 3.204019e-002
5416, -9.510427e-002, 8.356295e-002, 3.204019e-002
5417, -9.492610e-002, 8.257666e-002, 3.204019e-002
5418, -9.474793e-002, 8.159038e-002, 3.204019e-002
5419, -9.456975e-002, 8.060410e-002, 3.204019e-002
5420, -9.439158e-002, 7.961781e-002, 3.204019e-002
5421, -9.421341e-002, 7.863153e-002, 3.204019e-002
5422, -9.403524e-002, 7.764524e-002, 3.204019e-002
5423, -9.385706e-002, 7.665896e-002, 3.204019e-002
5424, -9.367889e-002, 7.567267e-002, 3.204019e-002
5425, -9.350072e-002, 7.468639e-002, 3.204019e-002
5426, -9.332255e-002, 7.370011e-002, 3.204019e-002
5427, -9.314437e-002, 7.271382e-002, 3.204019e-002
5428, -9.296620e-002, 7.172754e-002, 3.204019e-002
5429, -9.278803e-002, 7.074125e-002, 3.204019e-002
5430, -9.260986e-002, 6.975497e-002, 3.204019e-002
5431, -9.243168e-002, 6.876869e-002, 3.204019e-002
5432, -9.225351e-002, 6.778240e-002, 3.204019e-002
5433, -9.207534e-002, 6.679612e-002, 3.204019e-002
5434, -9.189717e-002, 6.580983e-002, 3.204019e-002
5435, -9.171899e-002, 6.482355e-002, 3.204019e-002
5436, -9.154082e-002, 6.383726e-002, 3.204019e-002
5437, -9.136265e-002, 6.285098e-002, 3.204019e-002
5438, -9.118448e-002, 6.186470e-002, 3.204019e-002
5439, -9.100630e-002, 6.087841e-002, 3.204019e-002
5440, -9.082813e-002, 5.989213e-002, 3.204019e-002
5441, -9.064996e-002, 5.890584e-002, 3.204019e-002
5442, -9.047179e-002, 5.791956e-002, 3.204019e-002
5443, -9.029361e-002, 5.693328e-002, 3.204019e-002
5444, -9.011544e-002, 5.594699e-002, 3.204019e-002
5445, -8.993727e-002, 5.496071e-002, 3.204019e-002
5446, -8.975910e-002, 5.397442e-002, 3.204019e-002
5447, -8.958092e-002, 5.298814e-002, 3.204019e-002
5448, -8.940275e-002, 5.200185e-002, 3.204019e-002
5449, -8.922458e-002, 5.101557e-002, 3.204019e-002
5450, -8.904641e-002, 5.002929e-002, 3.204019e-002
5451, -8.886823e-002, 4.904300e-002, 3.204019e-002
5452, -8.869006e-002, 4.805672e-002, 3.204019e-002
5453, -8.851189e-002, 4.707043e-002, 3.204019e-002
5454, -8.833372e-002, 4.608415e-002, 3.204019e-002
5455, -8.815554e-002, 4.509787e-002, 3.204019e-002
5456, -8.797737e-002, 4.411158e-002, 3.204019e-002
5457, -8.779920e-002, 4.312530e-002, 3.204019e-002
5458, -8.762102e-002, 4.213901e-002, 3.204019e-002
5459, -8.744285e-002, 4.115273e-002, 3.204019e-002
5460, -8.726468e-002, 4.016644e-002, 3.204019e-002
5461, -8.708651e-002, 3.918016e-002, 3.204019e-002
5462, -8.690833e-002, 3.819388e-002, 3.204019e-002
5463, -8.673016e-002, 3.720759e-002, 3.204019e-002
5464, -8.655199e-002, 3.622131e-002, 3.204019e-002
5465, -8.637382e-002, 3.523502e-002, 3.204019e-002
5466, -8.619564e-002, 3.424874e-002, 3.204019e-002
5467, -8.601747e-002, 3.326246e-002, 3.204019e-002
5468, -8.583930e-002, 3.227617e-002, 3.204019e-002
5469, -8.566113e-002, 3.128989e-002, 3.204019e-002
5470, -8.548295e-002, 3.030360e-002, 3.204019e-002
5471, -8.530478e-002, 2.931732e-002, 3.204019e-002
5472, -8.512661e-002, 2.833104e-002, 3.204019e-002
5473, -8.494844e-002, 2.734475e-002, 3.204019e-002
5474, -8.477026e-002, 2.635847e-002, 3.204019e-002
5475, -8.459209e-002, 2.537218e-002, 3.204019e-002
5476, -8.441392e-002, 2.438590e-002, 3.204019e-002
5477, -8.423575e-002, 2.339961e-002, 3.204019e-002
5478, -8.405757e-002, 2.241333e-002, 3.204019e-002
5479, -8.387940e-002, 2.142705e-002, 3.204019e-002
5480, -8.370123e-002, 2.044076e-002, 3.204019e-002
5481, -8.352306e-002, 1.945448e-002, 3.204019e-002
5482, -8.334492e-002, 1.846817e-002, 3.204023e-002
5483, -8.316694e-002, 1.748177e-002, 3.204046e-002
5484, -8.298922e-002, 1.649523e-002, 3.204101e-002
5485, -8.281182e-002, 1.550856e-002, 3.204191e-002
5486, -8.263486e-002, 1.452179e-002, 3.204332e-002
5487, -8.245862e-002, 1.353487e-002, 3.204553e-002
5488, -8.228323e-002, 1.254783e-002, 3.204867e-002
5489, -8.075639e-002, 1.281844e-002, 2.749549e-002
5490, -8.075488e-002, 1.281948e-002, 2.848427e-002
5491, -8.091805e-002, 1.278889e-002, 2.651927e-002
5492, -8.091310e-002, 1.279192e-002, 2.945935e-002
5493, -8.122665e-002, 1.273644e-002, 3.039468e-002
5494, -8.168728e-002, 1.265444e-002, 3.126551e-002
5495, -8.170095e-002, 1.264735e-002, 2.471192e-002
5496, -8.123574e-002, 1.273137e-002, 2.558282e-002
5497, -8.230094e-002, 1.253900e-002, 2.393065e-002
5498, -8.301921e-002, 1.240923e-002, 2.326045e-002
5499, -8.383617e-002, 1.226160e-002, 2.271956e-002
5500, -8.472957e-002, 1.210014e-002, 2.232269e-002
5501, -8.567509e-002, 1.192927e-002, 2.208063e-002
5502, -8.664698e-002, 1.175368e-002, 2.200000e-002
5503, -8.761873e-002, 1.157814e-002, 2.208304e-002
5504, -8.856385e-002, 1.140744e-002, 2.232750e-002
5505, -8.945651e-002, 1.124625e-002, 2.272673e-002
5506, -9.027233e-002, 1.109893e-002, 2.326985e-002
5507, -9.098899e-002, 1.096950e-002, 2.394197e-002
5508, -9.158692e-002, 1.086145e-002, 2.472469e-002
5509, -9.204990e-002, 1.077775e-002, 2.559670e-002
5510, -9.236535e-002, 1.072077e-002, 2.653422e-002
5511, -9.252470e-002, 1.069222e-002, 2.751164e-002
5512, -9.252366e-002, 1.069293e-002, 2.850224e-002
5513, -9.236231e-002, 1.072284e-002, 2.947904e-002
5514, -9.204511e-002, 1.078105e-002, 3.041539e-002
5515, -9.158079e-002, 1.086595e-002, 3.128577e-002
5516, -9.098213e-002, 1.097520e-002, 3.206647e-002
5517, -1.106226e-001, 1.693721e-001, 3.205839e-002
5518, -1.093581e-001, 1.624657e-001, 3.204024e-002
5519, -1.193148e-001, 1.677980e-001, 3.206369e-002
5520, -1.191367e-001, 1.668119e-001, 3.206369e-002
5521, -1.189584e-001, 1.658251e-001, 3.206369e-002
5522, -1.187801e-001, 1.648382e-001, 3.206369e-002
5523, -1.186019e-001, 1.638515e-001, 3.206369e-002
5524, -1.184237e-001, 1.628650e-001, 3.206369e-002
5525, -1.182455e-001, 1.618787e-001, 3.206369e-002
5526, -1.180673e-001, 1.608924e-001, 3.206369e-002
5527, -1.178891e-001, 1.599061e-001, 3.206369e-002
5528, -1.177110e-001, 1.589198e-001, 3.206369e-002
5529, -1.175328e-001, 1.579335e-001, 3.206369e-002
5530, -1.173546e-001, 1.569472e-001, 3.206369e-002
5531, -1.171764e-001, 1.559609e-001, 3.206369e-002
5532, -1.169983e-001, 1.549746e-001, 3.206369e-002
5533, -1.168201e-001, 1.539884e-001, 3.206369e-002
5534, -1.166419e-001, 1.530021e-001, 3.206369e-002
5535, -1.164638e-001, 1.520158e-001, 3.206369e-002
5536, -1.162856e-001, 1.510295e-001, 3.206369e-002
5537, -1.161074e-001, 1.500432e-001, 3.206369e-002
5538, -1.159292e-001, 1.490569e-001, 3.206369e-002
5539, -1.157511e-001, 1.480707e-001, 3.206369e-002
5540, -1.155729e-001, 1.470844e-001, 3.206369e-002
5541, -1.153947e-001, 1.460981e-001, 3.206369e-002
5542, -1.152166e-001, 1.451118e-001, 3.206369e-002
5543, -1.150384e-001, 1.441255e-001, 3.206369e-002
5544, -1.148602e-001, 1.431392e-001, 3.206369e-002
5545, -1.146820e-001, 1.421530e-001, 3.206369e-002
5546, -1.145039e-001, 1.411667e-001, 3.206369e-002
5547, -1.143257e-001, 1.401804e-001, 3.206369e-002
5548, -1.141475e-001, 1.391941e-001, 3.206369e-002
5549, -1.139693e-001, 1.382078e-001, 3.206369e-002
5550, -1.137912e-001, 1.372215e-001, 3.206369e-002
5551, -1.136130e-001, 1.362352e-001, 3.206369e-002
5552, -1.134348e-001, 1.352490e-001, 3.206369e-002
5553, -1.132567e-001, 1.342627e-001, 3.206369e-002
5554, -1.130785e-001, 1.332764e-001, 3.206369e-002
5555, -1.129003e-001, 1.322901e-001, 3.206369e-002
5556, -1.127221e-001, 1.313038e-001, 3.206369e-002
5557, -1.125440e-001, 1.303175e-001, 3.206369e-002
5558, -1.123658e-001, 1.293313e-001, 3.206369e-002
5559, -1.121876e-001, 1.283450e-001, 3.206369e-002
5560, -1.120094e-001, 1.273587e-001, 3.206369e-002
5561, -1.118313e-001, 1.263724e-001, 3.206369e-002
5562, -1.116531e-001, 1.253861e-001, 3.206369e-002
5563, -1.114749e-001, 1.243998e-001, 3.206369e-002
5564, -1.112968e-001, 1.234136e-001, 3.206369e-002
5565, -1.111186e-001, 1.224273e-001, 3.206369e-002
5566, -1.109404e-001, 1.214410e-001, 3.206369e-002
5567, -1.107622e-001, 1.204547e-001, 3.206369e-002
5568, -1.105841e-001, 1.194684e-001, 3.206369e-002
5569, -1.104059e-001, 1.184821e-001, 3.206369e-002
5570, -1.102277e-001, 1.174959e-001, 3.206369e-002
5571, -1.100495e-001, 1.165096e-001, 3.206369e-002
5572, -1.098714e-001, 1.155233e-001, 3.206369e-002
5573, -1.096932e-001, 1.145370e-001, 3.206369e-002
5574, -1.095150e-001, 1.135507e-001, 3.206369e-002
5575, -1.093369e-001, 1.125644e-001, 3.206369e-002
5576, -1.091587e-001, 1.115781e-001, 3.206369e-002
5577, -1.089805e-001, 1.105919e-001, 3.206369e-002
5578, -1.088023e-001, 1.096056e-001, 3.206369e-002
5579, -1.086242e-001, 1.086193e-001, 3.206369e-002
5580, -1.084460e-001, 1.076330e-001, 3.206369e-002
5581, -1.082678e-001, 1.066467e-001, 3.206369e-002
5582, -1.080896e-001, 1.056604e-001, 3.206369e-002
5583, -1.079115e-001, 1.046742e-001, 3.206369e-002
5584, -1.077333e-001, 1.036879e-001, 3.206369e-002
5585, -1.075551e-001, 1.027016e-001, 3.206369e-002
5586, -1.073770e-001, 1.017153e-001, 3.206369e-002
5587, -1.071988e-001, 1.007290e-001, 3.206369e-002
5588, -1.070206e-001, 9.974274e-002, 3.206369e-002
5589, -1.068424e-001, 9.875645e-002, 3.206369e-002
5590, -1.066643e-001, 9.777017e-002, 3.206369e-002
5591, -1.064861e-001, 9.678388e-002, 3.206369e-002
5592, -1.063079e-001, 9.579760e-002, 3.206369e-002
5593, -1.061298e-001, 9.481132e-002, 3.206369e-002
5594, -1.059516e-001, 9.382503e-002, 3.206369e-002
5595, -1.057734e-001, 9.283875e-002, 3.206369e-002
5596, -1.055952e-001, 9.185246e-002, 3.206369e-002
5597, -1.054171e-001, 9.086618e-002, 3.206369e-002
5598, -1.052389e-001, 8.987989e-002, 3.206369e-002
5599, -1.050607e-001, 8.889361e-002, 3.206369e-002
5600, -1.048825e-001, 8.790733e-002, 3.206369e-002
5601, -1.047044e-001, 8.692104e-002, 3.206369e-002
5602, -1.045262e-001, 8.593476e-002, 3.206369e-002
5603, -1.043480e-001, 8.494847e-002, 3.206369e-002
5604, -1.041699e-001, 8.396219e-002, 3.206369e-002
5605, -1.039917e-001, 8.297591e-002, 3.206369e-002
5606, -1.038135e-001, 8.198962e-002, 3.206369e-002
5607, -1.036353e-001, 8.100334e-002, 3.206369e-002
5608, -1.034572e-001, 8.001705e-002, 3.206369e-002
5609, -1.032790e-001, 7.903077e-002, 3.206369e-002
5610, -1.031008e-001, 7.804448e-002, 3.206369e-002
5611, -1.029226e-001, 7.705820e-002, 3.206369e-002
5612, -1.027445e-001, 7.607192e-002, 3.206369e-002
5613, -1.025663e-001, 7.508563e-002, 3.206369e-002
5614, -1.023881e-001, 7.409935e-002, 3.206369e-002
5615, -1.022100e-001, 7.311306e-002, 3.206369e-002
5616, -1.020318e-001, 7.212678e-002, 3.206369e-002
5617, -1.018536e-001, 7.114050e-002, 3.206369e-002
5618, -1.016754e-001, 7.015421e-002, 3.206369e-002
5619, -1.014973e-001, 6.916793e-002, 3.206369e-002
5620, -1.013191e-001, 6.818164e-002, 3.206369e-002
5621, -1.011409e-001, 6.719536e-002, 3.206369e-002
5622, -1.009627e-001, 6.620908e-002, 3.206369e-002
5623, -1.007846e-001, 6.522279e-002, 3.206369e-002
5624, -1.006064e-001, 6.423651e-002, 3.206369e-002
5625, -1.004282e-001, 6.325022e-002, 3.206369e-002
5626, -1.002501e-001, 6.226394e-002, 3.206369e-002
5627, -1.000719e-001, 6.127765e-002, 3.206369e-002
5628, -9.989371e-002, 6.029137e-002, 3.206369e-002
5629, -9.971554e-002, 5.930509e-002, 3.206369e-002
5630, -9.953737e-002, 5.831880e-002, 3.206369e-002
5631, -9.935919e-002, 5.733252e-002, 3.206369e-002
5632, -9.918102e-002, 5.634623e-002, 3.206369e-002
5633, -9.900285e-002, 5.535995e-002, 3.206369e-002
5634, -9.882467e-002, 5.437367e-002, 3.206369e-002
5635, -9.864650e-002, 5.338738e-002, 3.206369e-002
5636, -9.846833e-002, 5.240110e-002, 3.206369e-002
5637, -9.829016e-002, 5.141481e-002, 3.206369e-002
5638, -9.811198e-002, 5.042853e-002, 3.206369e-002
5639, -9.793381e-002, 4.944224e-002, 3.206369e-002
5640, -9.775564e-002, 4.845596e-002, 3.206369e-002
5641, -9.757747e-002, 4.746968e-002, 3.206369e-002
5642, -9.739929e-002, 4.648339e-002, 3.206369e-002
5643, -9.722112e-002, 4.549711e-002, 3.206369e-002
5644, -9.704295e-002, 4.451082e-002, 3.206369e-002
5645, -9.686478e-002, 4.352454e-002, 3.206369e-002
5646, -9.668660e-002, 4.253826e-002, 3.206369e-002
5647, -9.650843e-002, 4.155197e-002, 3.206369e-002
5648, -9.633026e-002, 4.056569e-002, 3.206369e-002
5649, -9.615209e-002, 3.957940e-002, 3.206369e-002
5650, -9.597391e-002, 3.859312e-002, 3.206369e-002
5651, -9.579574e-002, 3.760683e-002, 3.206369e-002
5652, -9.561757e-002, 3.662055e-002, 3.206369e-002
5653, -9.543940e-002, 3.563427e-002, 3.206369e-002
5654, -9.526122e-002, 3.464798e-002, 3.206369e-002
5655, -9.508305e-002, 3.366170e-002, 3.206369e-002
5656, -9.490488e-002, 3.267541e-002, 3.206369e-002
5657, -9.472671e-002, 3.168913e-002, 3.206369e-002
5658, -9.454853e-002, 3.070285e-002, 3.206369e-002
5659, -9.437036e-002, 2.971656e-002, 3.206369e-002
5660, -9.419219e-002, 2.873028e-002, 3.206369e-002
5661, -9.401402e-002, 2.774399e-002, 3.206369e-002
5662, -9.383584e-002, 2.675771e-002, 3.206369e-002
5663, -9.365767e-002, 2.577142e-002, 3.206369e-002
5664, -9.347950e-002, 2.478514e-002, 3.206369e-002
5665, -9.330133e-002, 2.379886e-002, 3.206369e-002
5666, -9.312315e-002, 2.281257e-002, 3.206369e-002
5667, -9.294498e-002, 2.182629e-002, 3.206369e-002
5668, -9.276681e-002, 2.084000e-002, 3.206369e-002
5669, -9.258864e-002, 1.985372e-002, 3.206369e-002
5670, -9.241046e-002, 1.886744e-002, 3.206369e-002
5671, -9.223229e-002, 1.788115e-002, 3.206369e-002
5672, -9.205411e-002, 1.689485e-002, 3.206370e-002
5673, -9.187588e-002, 1.590849e-002, 3.206374e-002
5674, -9.169754e-002, 1.492199e-002, 3.206387e-002
5675, -9.151901e-002, 1.393532e-002, 3.206418e-002
5676, -9.134023e-002, 1.294853e-002, 3.206474e-002
5677, -9.116120e-002, 1.196175e-002, 3.206555e-002
5678, -1.100250e-001, 1.694823e-001, 3.127565e-002
5679, -1.095622e-001, 1.695666e-001, 3.040397e-002
5680, -1.092468e-001, 1.696236e-001, 2.946732e-002
5681, -1.090874e-001, 1.696523e-001, 2.849114e-002
5682, -1.090880e-001, 1.696523e-001, 2.750165e-002
5683, -1.092487e-001, 1.696236e-001, 2.652550e-002
5684, -1.095653e-001, 1.695670e-001, 2.558912e-002
5685, -1.100295e-001, 1.694840e-001, 2.471807e-002
5686, -1.106284e-001, 1.693765e-001, 2.393625e-002
5687, -1.113458e-001, 1.692467e-001, 2.326514e-002
5688, -1.121621e-001, 1.690985e-001, 2.272315e-002
5689, -1.130550e-001, 1.689365e-001, 2.232509e-002
5690, -1.140002e-001, 1.687652e-001, 2.208183e-002
5691, -1.149720e-001, 1.685895e-001, 2.200000e-002
5692, -1.159439e-001, 1.684140e-001, 2.208184e-002
5693, -1.168893e-001, 1.682436e-001, 2.232510e-002
5694, -1.177824e-001, 1.680830e-001, 2.272317e-002
5695, -1.185989e-001, 1.679362e-001, 2.326517e-002
5696, -1.193165e-001, 1.678071e-001, 2.393632e-002
5697, -1.199153e-001, 1.676983e-001, 2.471832e-002
5698, -1.203793e-001, 1.676137e-001, 2.558984e-002
5699, -1.206958e-001, 1.675559e-001, 2.652710e-002
5700, -1.208562e-001, 1.675263e-001, 2.750454e-002
5701, -1.208561e-001, 1.675255e-001, 2.849549e-002
5702, -1.206954e-001, 1.675534e-001, 2.947292e-002
5703, -1.203785e-001, 1.676092e-001, 3.041018e-002
5704, -1.199141e-001, 1.676915e-001, 3.128169e-002
5705, -1.094785e-001, 1.665220e-001, 3.125790e-002
5706, -1.096612e-001, 1.675104e-001, 3.126418e-002
5707, -1.091170e-001, 1.645467e-001, 3.125072e-002
5708, -1.092973e-001, 1.655339e-001, 3.125378e-002
5709, -1.089380e-001, 1.635602e-001, 3.124966e-002
5710, -1.098437e-001, 1.684973e-001, 3.127053e-002
5711, -9.175958e-002, 1.185231e-002, 3.128486e-002
5712, -1.078682e-001, 1.576425e-001, 3.124842e-002
5713, -1.080464e-001, 1.586288e-001, 3.124842e-002
5714, -1.082245e-001, 1.596150e-001, 3.124842e-002
5715, -8.141372e-002, 1.371560e-002, 2.558241e-002
5716, -8.109621e-002, 1.377338e-002, 2.651805e-002
5717, -1.084027e-001, 1.606013e-001, 3.124842e-002
5718, -1.085809e-001, 1.615876e-001, 3.124846e-002
5719, -1.076900e-001, 1.566562e-001, 3.124842e-002
5720, -1.075118e-001, 1.556699e-001, 3.124842e-002
5721, -1.073337e-001, 1.546836e-001, 3.124842e-002
5722, -1.071555e-001, 1.536973e-001, 3.124842e-002
5723, -1.069773e-001, 1.527111e-001, 3.124842e-002
5724, -1.067992e-001, 1.517248e-001, 3.124841e-002
5725, -1.066210e-001, 1.507385e-001, 3.124841e-002
5726, -1.064428e-001, 1.497522e-001, 3.124841e-002
5727, -1.062646e-001, 1.487659e-001, 3.124841e-002
5728, -1.060865e-001, 1.477796e-001, 3.124841e-002
5729, -1.059083e-001, 1.467933e-001, 3.124841e-002
5730, -1.057301e-001, 1.458071e-001, 3.124841e-002
5731, -1.055519e-001, 1.448208e-001, 3.124841e-002
5732, -1.053738e-001, 1.438345e-001, 3.124841e-002
5733, -1.051956e-001, 1.428482e-001, 3.124841e-002
5734, -1.050174e-001, 1.418619e-001, 3.124841e-002
5735, -1.048393e-001, 1.408756e-001, 3.124841e-002
5736, -1.046611e-001, 1.398894e-001, 3.124841e-002
5737, -1.044829e-001, 1.389031e-001, 3.124841e-002
5738, -1.043047e-001, 1.379168e-001, 3.124841e-002
5739, -1.041266e-001, 1.369305e-001, 3.124841e-002
5740, -1.039484e-001, 1.359442e-001, 3.124841e-002
5741, -1.037702e-001, 1.349579e-001, 3.124841e-002
5742, -1.035920e-001, 1.339717e-001, 3.124841e-002
5743, -1.034139e-001, 1.329854e-001, 3.124841e-002
5744, -1.032357e-001, 1.319991e-001, 3.124841e-002
5745, -1.030575e-001, 1.310128e-001, 3.124841e-002
5746, -1.028794e-001, 1.300265e-001, 3.124841e-002
5747, -1.027012e-001, 1.290402e-001, 3.124841e-002
5748, -1.025230e-001, 1.280539e-001, 3.124841e-002
5749, -1.023448e-001, 1.270677e-001, 3.124841e-002
5750, -1.021667e-001, 1.260814e-001, 3.124841e-002
5751, -1.019885e-001, 1.250951e-001, 3.124841e-002
5752, -1.018103e-001, 1.241088e-001, 3.124841e-002
5753, -1.016322e-001, 1.231225e-001, 3.124841e-002
5754, -1.014540e-001, 1.221362e-001, 3.124841e-002
5755, -1.012758e-001, 1.211500e-001, 3.124841e-002
5756, -1.010976e-001, 1.201637e-001, 3.124841e-002
5757, -1.009195e-001, 1.191774e-001, 3.124841e-002
5758, -1.007413e-001, 1.181911e-001, 3.124841e-002
5759, -1.005631e-001, 1.172048e-001, 3.124841e-002
5760, -1.003849e-001, 1.162185e-001, 3.124841e-002
5761, -1.002068e-001, 1.152323e-001, 3.124841e-002
5762, -1.000286e-001, 1.142460e-001, 3.124841e-002
5763, -9.985043e-002, 1.132597e-001, 3.124841e-002
5764, -9.967225e-002, 1.122734e-001, 3.124841e-002
5765, -9.949408e-002, 1.112871e-001, 3.124841e-002
5766, -9.931591e-002, 1.103008e-001, 3.124841e-002
5767, -9.913773e-002, 1.093145e-001, 3.124841e-002
5768, -9.895956e-002, 1.083283e-001, 3.124841e-002
5769, -9.878139e-002, 1.073420e-001, 3.124841e-002
5770, -9.860322e-002, 1.063557e-001, 3.124841e-002
5771, -9.842504e-002, 1.053694e-001, 3.124841e-002
5772, -9.824687e-002, 1.043831e-001, 3.124841e-002
5773, -9.806870e-002, 1.033968e-001, 3.124841e-002
5774, -9.789053e-002, 1.024106e-001, 3.124841e-002
5775, -9.771235e-002, 1.014243e-001, 3.124841e-002
5776, -9.753418e-002, 1.004380e-001, 3.124841e-002
5777, -9.735601e-002, 9.945171e-002, 3.124841e-002
5778, -9.717784e-002, 9.846542e-002, 3.124841e-002
5779, -9.699966e-002, 9.747914e-002, 3.124841e-002
5780, -9.682149e-002, 9.649286e-002, 3.124841e-002
5781, -9.664332e-002, 9.550657e-002, 3.124841e-002
5782, -9.646515e-002, 9.452029e-002, 3.124841e-002
5783, -9.628697e-002, 9.353400e-002, 3.124841e-002
5784, -9.610880e-002, 9.254772e-002, 3.124841e-002
5785, -9.593063e-002, 9.156143e-002, 3.124841e-002
5786, -9.575246e-002, 9.057515e-002, 3.124841e-002
5787, -9.557428e-002, 8.958887e-002, 3.124841e-002
5788, -9.539611e-002, 8.860258e-002, 3.124841e-002
5789, -9.521794e-002, 8.761630e-002, 3.124841e-002
5790, -9.503977e-002, 8.663001e-002, 3.124841e-002
5791, -9.486159e-002, 8.564373e-002, 3.124841e-002
5792, -9.468342e-002, 8.465745e-002, 3.124841e-002
5793, -9.450525e-002, 8.367116e-002, 3.124841e-002
5794, -9.432708e-002, 8.268488e-002, 3.124841e-002
5795, -9.414890e-002, 8.169859e-002, 3.124841e-002
5796, -9.397073e-002, 8.071231e-002, 3.124841e-002
5797, -9.379256e-002, 7.972602e-002, 3.124841e-002
5798, -9.361439e-002, 7.873974e-002, 3.124841e-002
5799, -9.343621e-002, 7.775346e-002, 3.124841e-002
5800, -9.325804e-002, 7.676717e-002, 3.124841e-002
5801, -9.307987e-002, 7.578089e-002, 3.124841e-002
5802, -9.290170e-002, 7.479460e-002, 3.124841e-002
5803, -9.272352e-002, 7.380832e-002, 3.124841e-002
5804, -9.254535e-002, 7.282204e-002, 3.124841e-002
5805, -9.236718e-002, 7.183575e-002, 3.124841e-002
5806, -9.218900e-002, 7.084947e-002, 3.124841e-002
5807, -9.201083e-002, 6.986318e-002, 3.124841e-002
5808, -9.183266e-002, 6.887690e-002, 3.124841e-002
5809, -9.165449e-002, 6.789062e-002, 3.124841e-002
5810, -9.147631e-002, 6.690433e-002, 3.124841e-002
5811, -9.129814e-002, 6.591805e-002, 3.124841e-002
5812, -9.111997e-002, 6.493176e-002, 3.124841e-002
5813, -9.094180e-002, 6.394548e-002, 3.124841e-002
5814, -9.076362e-002, 6.295919e-002, 3.124841e-002
5815, -9.058545e-002, 6.197291e-002, 3.124841e-002
5816, -9.040728e-002, 6.098663e-002, 3.124841e-002
5817, -9.022911e-002, 6.000034e-002, 3.124841e-002
5818, -9.005093e-002, 5.901406e-002, 3.124841e-002
5819, -8.987276e-002, 5.802777e-002, 3.124841e-002
5820, -8.969459e-002, 5.704149e-002, 3.124841e-002
5821, -8.951642e-002, 5.605521e-002, 3.124841e-002
5822, -8.933824e-002, 5.506892e-002, 3.124841e-002
5823, -8.916007e-002, 5.408264e-002, 3.124841e-002
5824, -8.898190e-002, 5.309635e-002, 3.124841e-002
5825, -8.880373e-002, 5.211007e-002, 3.124841e-002
5826, -8.862555e-002, 5.112378e-002, 3.124841e-002
5827, -8.844738e-002, 5.013750e-002, 3.124841e-002
5828, -8.826921e-002, 4.915122e-002, 3.124841e-002
5829, -8.809104e-002, 4.816493e-002, 3.124841e-002
5830, -8.791286e-002, 4.717865e-002, 3.124841e-002
5831, -8.773469e-002, 4.619236e-002, 3.124841e-002
5832, -8.755652e-002, 4.520608e-002, 3.124841e-002
5833, -8.737835e-002, 4.421980e-002, 3.124841e-002
5834, -8.720017e-002, 4.323351e-002, 3.124841e-002
5835, -8.702200e-002, 4.224723e-002, 3.124841e-002
5836, -8.684383e-002, 4.126094e-002, 3.124841e-002
5837, -8.666566e-002, 4.027466e-002, 3.124841e-002
5838, -8.648748e-002, 3.928837e-002, 3.124841e-002
5839, -8.630931e-002, 3.830209e-002, 3.124841e-002
5840, -8.613114e-002, 3.731581e-002, 3.124841e-002
5841, -8.595296e-002, 3.632952e-002, 3.124841e-002
5842, -8.577479e-002, 3.534324e-002, 3.124841e-002
5843, -8.559662e-002, 3.435695e-002, 3.124841e-002
5844, -8.541845e-002, 3.337067e-002, 3.124841e-002
5845, -8.524027e-002, 3.238439e-002, 3.124841e-002
5846, -8.506210e-002, 3.139810e-002, 3.124841e-002
5847, -8.488393e-002, 3.041182e-002, 3.124841e-002
5848, -8.470576e-002, 2.942553e-002, 3.124841e-002
5849, -8.452758e-002, 2.843925e-002, 3.124841e-002
5850, -8.434941e-002, 2.745296e-002, 3.124841e-002
5851, -8.417124e-002, 2.646668e-002, 3.124841e-002
5852, -8.399307e-002, 2.548040e-002, 3.124841e-002
5853, -8.381489e-002, 2.449411e-002, 3.124841e-002
5854, -8.363672e-002, 2.350783e-002, 3.124841e-002
5855, -8.345855e-002, 2.252154e-002, 3.124841e-002
5856, -8.328038e-002, 2.153526e-002, 3.124841e-002
5857, -8.310220e-002, 2.054898e-002, 3.124842e-002
5858, -8.292409e-002, 1.956264e-002, 3.124852e-002
5859, -8.274624e-002, 1.857613e-002, 3.124908e-002
5860, -8.256888e-002, 1.758930e-002, 3.125046e-002
5861, -8.239200e-002, 1.660223e-002, 3.125266e-002
5862, -8.221547e-002, 1.561508e-002, 3.125540e-002
